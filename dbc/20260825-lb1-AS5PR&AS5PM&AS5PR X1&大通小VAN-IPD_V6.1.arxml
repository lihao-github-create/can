                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="53d5d9660a373befaee505d5551be402">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c7557dc3a093daa9343b0b866fbca4f">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="41e3acebbe2633e49301d43da985411d">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved49</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved49</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e59856ee67c83377ab2cf80c5288e25e">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ce0f370e77c38b0af3f9869b4fbf8a4">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved60</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved60</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="038ddf84c36b32d7806f7a6d2154f8d8">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a23755cafaab318a8530c11ce3becb06">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91b26885b8963775828a80ff3f163a9a">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved81</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved81</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="acaeb0b4e7b83eaeb3798693e060de8d">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved87</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="854047d58c8733a588572be42dd23fb3">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b376236e2d23db7a00e0529ab49c410">
              <SHORT-NAME>LHZCUeFs12Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs12Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a48e26087243312bed92a5b331eb82e">
              <SHORT-NAME>LHZCUeFs12DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs12DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5892f462fb943a64903f70ffc35167a8">
              <SHORT-NAME>LHZCUeFs12Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs12Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a7f55a887063fde81c4af8ca192233d">
              <SHORT-NAME>LHZCUeFs13Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs13Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e82b432f34831649b718c671af1898d">
              <SHORT-NAME>LHZCUeFs13DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs13DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef13682e3bc53f0088f986d2511dd996">
              <SHORT-NAME>LHZCUeFs13Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs13Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="afe4547f67a232369b59b738cd6b8f4c">
              <SHORT-NAME>LHZCUeFs15Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs15Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ac708f0be6838a2a1684a8882fc7b6c">
              <SHORT-NAME>LHZCUeFs17Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs17Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="56ed25e6c4243fdc98e90127aeed18f9">
              <SHORT-NAME>LHZCUeFs4Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs4Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99d5d031a2fc3001aedebf06d377096b">
              <SHORT-NAME>LHZCUeFs6Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs6Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fcea93f622b43fbeaaa66ec15d8b5a8d">
              <SHORT-NAME>LHZCUeFs8Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeFs8Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="664e2302a7e33f6ba2a08130eaa27638">
              <SHORT-NAME>LHZCUeSw12Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw12Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="445cd59760433da8b5addae595838b5d">
              <SHORT-NAME>LHZCUeSw12DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw12DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c24199ad6c13cecaa88d0ccb292e895">
              <SHORT-NAME>LHZCUeSw12Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw12Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eacfacaa3ecc390387c899a92bffbf9f">
              <SHORT-NAME>LHZCUeSw13Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw13Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88aa222373b5397e9e98a9594ee6f6d4">
              <SHORT-NAME>LHZCUeSw13DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw13DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="982bdf26d95f3d50be6eac50d00fdd90">
              <SHORT-NAME>LHZCUeSw13Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw13Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c6e2eb2610c34b09c23fec3b9158f03">
              <SHORT-NAME>LHZCUeSw14Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw14Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2e8b81d7c74388885c21baa14b61711">
              <SHORT-NAME>LHZCUeSw14DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw14DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6b1eed1ea38c330c8c74289ae9cb1812">
              <SHORT-NAME>LHZCUeSw14Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw14Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b30afd0a547306eba6bb1f80a284d76">
              <SHORT-NAME>LHZCUeSw15Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw15Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4758dd7e2428354caa0ac9b28fb09f14">
              <SHORT-NAME>LHZCUeSw15DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw15DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d1ab49e441b431ab8d327cb9805ae602">
              <SHORT-NAME>LHZCUeSw15Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw15Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e76700b19def34e4ae8b58b5543eda83">
              <SHORT-NAME>LHZCUeSw16Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw16Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="80896b31e04c3939aa64d23a9c5d0b99">
              <SHORT-NAME>LHZCUeSw16DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw16DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d4988459a5be3450abb7478b73f10104">
              <SHORT-NAME>LHZCUeSw16Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw16Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="166f3b389f3a3b4c94c2565cb22352b3">
              <SHORT-NAME>LHZCUeSw17Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw17Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="55b8d352bb18395294a673a50254345a">
              <SHORT-NAME>LHZCUeSw17DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw17DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9e0e62a9733328da0d0ef5c2101ff13">
              <SHORT-NAME>LHZCUeSw17Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw17Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93e094f47b1f304dbbdf2c5123b828b8">
              <SHORT-NAME>LHZCUeSw1Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw1Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="501f89534e0d30c2971775cc2cc9e1d2">
              <SHORT-NAME>LHZCUeSw20Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw20Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8545e5bfa5bf30c39b50f8734df82309">
              <SHORT-NAME>LHZCUeSw24Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw24Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f7a59c330d443258b2dd000531cbba1a">
              <SHORT-NAME>LHZCUeSw26Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw26Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="adf379f77fb43f73a7247595fe0f1726">
              <SHORT-NAME>LHZCUeSw27Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw27Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="28c97aed64ab3557847e36cdf20f8033">
              <SHORT-NAME>LHZCUeSw29Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw29Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="efffb6c4b5073044896f3393afb94765">
              <SHORT-NAME>LHZCUeSw30Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw30Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d6729ffee4b3f1798b67d01e0b4c0c9">
              <SHORT-NAME>LHZCUeSw31Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw31Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="658a10dea9d432319b208ff0a8ebcf64">
              <SHORT-NAME>LHZCUeSw32Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw32Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fa59b89477403e159ae55f39ac0747fe">
              <SHORT-NAME>LHZCUeSw36Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw36Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc8e8b4729e73b7680d451ce46e6976e">
              <SHORT-NAME>LHZCUeSw3Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw3Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da891e3e049b3a0b9d3c5d4a88f89ceb">
              <SHORT-NAME>LHZCUeSw40Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw40Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b3e7bd680ef3ff0af96ddd54df1c3ba">
              <SHORT-NAME>LHZCUeSw43Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw43Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c6d788b03103cee8a30e88deccfa2ac">
              <SHORT-NAME>LHZCUeSw44Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw44Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1694ac4175eb389a80102d78a2524925">
              <SHORT-NAME>LHZCUeSw45Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw45Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="022532c9c7393094af0fc4815c5c4ede">
              <SHORT-NAME>LHZCUeSw46Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw46Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32c99b6e0b193cc6b1df1cc0fcb7810f">
              <SHORT-NAME>LHZCUeSw47Crnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUeSw47Crnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5e00446405b3d84affec243ee1cbbec">
              <SHORT-NAME>LHandAntFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHandAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="593ed28b40f83885a19106bf7442dcca">
              <SHORT-NAME>LKADrvrTkovReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKADrvrTkovReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d59d1b4aefd53764807b6a84012e4641">
              <SHORT-NAME>LKAReqAng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAReqAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91ee2e85c2fc3a4189b93b04188101f5">
              <SHORT-NAME>LKAReqAngSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAReqAngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67e32f7758833b2292d54979dac0b12f">
              <SHORT-NAME>LKAReqToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAReqToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="98126a7c045a3f8487c21b224f1f027c">
              <SHORT-NAME>LKAReqToqSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAReqToqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d979e6b810ec3a689be7fa59548c0302">
              <SHORT-NAME>LKASysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKASysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f92dcfd637b83545b4045fdf64d2233d">
              <SHORT-NAME>LKASysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKASysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="41597ee0aedb33ef86c9c076457876d2">
              <SHORT-NAME>LKAToqReqValMax</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAToqReqValMax</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="49dc86a5da6a3a8988efe61ce3c002c6">
              <SHORT-NAME>LKAToqReqValMin</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LKAToqReqValMin</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="102a2e0faad13a40ad9625e52fe8b642">
              <SHORT-NAME>LMainBeamLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LMainBeamLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1213b98ff5a73b6c8d3b123dea33c0c7">
              <SHORT-NAME>LMainBeamLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LMainBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9b7b4f62e213b8281ab1805d037a6d8">
              <SHORT-NAME>LNonDrvnWhlRotlDircn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="00846425b34f3f14836f91106ab1c9cb">
              <SHORT-NAME>LNonDrvnWhlRotlDircnSdslSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDircnSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fe57a339c005362395a690633f142efa">
              <SHORT-NAME>LNonDrvnWhlRotlDistPC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDistPC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6eca181419a7346a9101f3a619a090c0">
              <SHORT-NAME>LNonDrvnWhlRotlDistT</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDistT</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d64b74187ac03d77958f76c48773c36d">
              <SHORT-NAME>LNonDrvnWhlRotlDistTRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDistTRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08fb11f9abe73ebf93696c81896cd8d5">
              <SHORT-NAME>LNonDrvnWhlRotlDistV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlDistV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce73d7ab0ec63c579cf83e7121a2540f">
              <SHORT-NAME>LNonDrvnWhlRotlRstOcd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlRstOcd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b3ba126b41443a30a6b98be4f71fa243">
              <SHORT-NAME>LNonDrvnWhlRotlSeqNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LNonDrvnWhlRotlSeqNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="55efa02057973e418cfd2abadd230b15">
              <SHORT-NAME>LOtsdMirActSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LOtsdMirActSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf61d33e651236bda2f9a7e9e38d1b45">
              <SHORT-NAME>LRCTAWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LRCTAWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58f044aef396374784544b370d03e5c6">
              <SHORT-NAME>LRevsLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LRevsLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6ff499f41d93f3b85b5498e35351b55">
              <SHORT-NAME>LVBMDisChrgMOSCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBMDisChrgMOSCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fa398c050114331d892d3de1b32b018a">
              <SHORT-NAME>LVBM_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fdda014ec79431b1b5e8361d3312fecf">
              <SHORT-NAME>LVBM_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="199866205e7f300489f625a290069a80">
              <SHORT-NAME>LVBM_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4add450a7e1c3033991c6fc59d3133f8">
              <SHORT-NAME>LVBM_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2e97f28670d398291d72a1cbcbf1b57">
              <SHORT-NAME>LVBM_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ded681b7c038337d87dffef632791626">
              <SHORT-NAME>LVBM_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8340739e32732968192a93625a3ab43">
              <SHORT-NAME>LVBM_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="845d794515fd3bfb8d033231839ec9c3">
              <SHORT-NAME>LVBM_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9e9d658a8c8337c897df6cf87309bd1">
              <SHORT-NAME>LVBM_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67ee5fdbb3d83fe0863c3b23270dbfd3">
              <SHORT-NAME>LVBM_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c0a7d105f0073180af9f568e911de93a">
              <SHORT-NAME>LVBM_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d99931cb425363e8adaf77071f1a8ae">
              <SHORT-NAME>LVBM_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBM_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c147db175d0237a68821c055b1955ad8">
              <SHORT-NAME>LVBatChrgReqInhbt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBatChrgReqInhbt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="908973b1e6e03bd0a01bd3b87a8d31be">
              <SHORT-NAME>LVBatChrgReqRaw</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBatChrgReqRaw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6700dea5d65d3a9cafe523980f87500b">
              <SHORT-NAME>LVBatEnrgLow</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBatEnrgLow</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7bf18f50b33633a2aea1707d8a407ccf">
              <SHORT-NAME>LVBatEnrgSufct</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBatEnrgSufct</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b34238a22245327aba68357a2df25a66">
              <SHORT-NAME>LVBatSelfWakeupFlg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LVBatSelfWakeupFlg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b179e2f8df3334b598f21b20a257f83e">
              <SHORT-NAME>Lane0_C0</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_C0</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="40ee4d543c303cf4b66c984c14b4db3e">
              <SHORT-NAME>Lane0_C1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_C1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ecf6708811a03d9ba43734a5a1e91f69">
              <SHORT-NAME>Lane0_C2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_C2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca1eae4e4ada36a1a3c4576873597d88">
              <SHORT-NAME>Lane0_C3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_C3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3be42fd529123bdba66a3c1178461c6d">
              <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01b9760a2641361ba5d204010e9e9573">
              <SHORT-NAME>Lane0_ID</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_ID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd770622e3ff3f6ebdc9fed96f20de5b">
              <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_MarkerColor</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="afbb1383a4c6389489326e68c54d84ce">
              <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_MarkerType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="947326cfbb2e3c8c82aa4e0f5ce67844">
              <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_Part0_SyncFrameIndex</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b51a4c8a94d03f9eb165cd2d5154f915">
              <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_ViewRangeEnd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cee9483c0f39348f83f234466bae664f">
              <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_ViewRangeStart</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b559f2141d82342ab14b6383a376eded">
              <SHORT-NAME>Lane0_location</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane0_location</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="768ef519fce6369f9bea855d0fdba44e">
              <SHORT-NAME>Lane1_C0</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_C0</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e7b4237e58730c58923b791a6e6ff2e">
              <SHORT-NAME>Lane1_C1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_C1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba6b1b3d09a634b0916ff2092998ed15">
              <SHORT-NAME>Lane1_C2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_C2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="517720d1e7a33d5a95d87971fbeacce0">
              <SHORT-NAME>Lane1_C3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_C3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="50bfeb14378135b2a0e94ae098a11bbe">
              <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8bffba613d63102b9c8d81f030a7fa4">
              <SHORT-NAME>Lane1_ID</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_ID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fe346a578a443dc9b5be434a2fc87f33">
              <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_MarkerColor</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b22d5ca382ad37f8b6f2d18d11f65b25">
              <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_MarkerType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78b64b30082c3ca9bda5532bfcab7451">
              <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_Part0_SyncFrameIndex</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81c955b7cf7d367fb993a45c39292fc7">
              <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_ViewRangeEnd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48d94cd63b9d370e9a2ebbe0754a49a2">
              <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_ViewRangeStart</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1edb9fda53ed359091812e402ca5e147">
              <SHORT-NAME>Lane1_location</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane1_location</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed7acb5d3fb83041a3e2efe64d7e4773">
              <SHORT-NAME>Lane2_C0</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_C0</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78fe0852aa4d32bca43e7a971c1ae1f4">
              <SHORT-NAME>Lane2_C1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_C1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b8808f64a9532f0ad90ce994ddb1c27">
              <SHORT-NAME>Lane2_C2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_C2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f00b5723b0da3f2292e5d0c9ba596754">
              <SHORT-NAME>Lane2_C3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_C3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59f0d8cce87d3008926aa7dc448ef9f5">
              <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2017926b6e433eea94bbfc37eba4d242">
              <SHORT-NAME>Lane2_ID</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_ID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="324aae82c2c53440ae8cf873d4469e90">
              <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_MarkerColor</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9730073784be39d5959d77949019dc48">
              <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_MarkerType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4cf4711c7a7b397da5c38a247fffe748">
              <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_Part0_SyncFrameIndex</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99328d7d7f9934e8a725eb7bdac248bc">
              <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_ViewRangeEnd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1f8272b8587354fb5ce01a1ff9d6497">
              <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_ViewRangeStart</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="97409ca6351f382399d59079ccbd9ac0">
              <SHORT-NAME>Lane2_location</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane2_location</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd37d64d07ce338b8c85da4c56aeda2a">
              <SHORT-NAME>Lane3_C0</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_C0</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e38067fc21933e838d0b795f4f248b8a">
              <SHORT-NAME>Lane3_C1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_C1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a6f6ebb13e933e4bddbb19c70d46366">
              <SHORT-NAME>Lane3_C2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_C2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="661c1d5d42093e09bbb1ec7e9e9e7498">
              <SHORT-NAME>Lane3_C3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_C3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67948aae449b3e22a10da0c76b5678ca">
              <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3e97fbdd3fd370a8baaedf590101500">
              <SHORT-NAME>Lane3_ID</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_ID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="053be2b95c6533e5abecaf7d416291bb">
              <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_MarkerColor</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a18c4ae8d80231f69b52e78613e94dfd">
              <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_MarkerType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c58b12e6d3ba3249b5c393628b6e16a4">
              <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_Part0_SyncFrameIndex</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="23a1e5ac0fda3c23ae3385cc1d841c54">
              <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_ViewRangeEnd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f424a44adf434bc8005b26c4991adfb">
              <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_ViewRangeStart</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62484fb79ad437508b9611d8c5199a24">
              <SHORT-NAME>Lane3_location</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Lane3_location</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d17c1bf6d6f3af7b30670c167c06353">
              <SHORT-NAME>LatSigma</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LatSigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de65bbbc26bb3bb0b945a5ae05e65f1d">
              <SHORT-NAME>LatitudeRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LatitudeRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d1a0f5e1c663319a326fdce67555335">
              <SHORT-NAME>LdspcOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LdspcOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9a003eaa86073f20a92c39184cfbe3a9">
              <SHORT-NAME>LdspcOpenStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LdspcOpenStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="84025d19ea923e958974e4fd295c0c7e">
              <SHORT-NAME>LdspcRlseSwtActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LdspcRlseSwtActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd3b0e7aa6503ce28cee5db2e1b983cd">
              <SHORT-NAME>LeftEyeOccludeStatus_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LeftEyeOccludeStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="828a7f13c0c5331c9b03781446ff6a6a">
              <SHORT-NAME>LghtWlcmMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LghtWlcmMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="179eef6b79b431b18cc69a3b59d4288d">
              <SHORT-NAME>LonSigma</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LonSigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b16ec347b18631faa1a871fdb2ac4483">
              <SHORT-NAME>LongitudeRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LongitudeRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9bf43df24a993d0e9d07c4e15ca4fac1">
              <SHORT-NAME>LowBttySta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LowBttySta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1cc2ed15a94c30459cd84631c0ced473">
              <SHORT-NAME>LowTemWtrPumpAfterRunLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LowTemWtrPumpAfterRunLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64150f70e9c8341389db6a05451e9138">
              <SHORT-NAME>LowTemWtrPumpTrgtSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LowTemWtrPumpTrgtSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69e0b30d93ef3b30a65ba28dc82c9b02">
              <SHORT-NAME>MMCUPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCUPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d4747e509e013b73aaa0b4e0b415a7f3">
              <SHORT-NAME>MMCU_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d5796998e12134fe9eb7ddb20e08b8b9">
              <SHORT-NAME>MMCU_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e778ba825f273a3795e1e7e55060aa40">
              <SHORT-NAME>MMCU_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e20be46042de37d39bdff087da7927f3">
              <SHORT-NAME>MMCU_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a47f5d55e0c3bba9f54bb9c16b45157">
              <SHORT-NAME>MMCU_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0116374e666c353ea9c19f0f08d707e7">
              <SHORT-NAME>MMCU_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="caee0fd867653b46a07872e9c58f1433">
              <SHORT-NAME>MMCU_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b849905ae3c3817b4e5fc0bf300eb6a">
              <SHORT-NAME>MMCU_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9709b45885ff3f588bb7e32171f2c3b4">
              <SHORT-NAME>MMCU_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94f7544cc9053f018f3b9d18df034aa9">
              <SHORT-NAME>MMCU_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63fadde0286430999b42d3dbc906b591">
              <SHORT-NAME>MMCU_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MMCU_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69d707cc7c543c18b2a77854ee6266c3">
              <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MONSAMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8ecde31b1b78312096e050ff13b1eaf7">
              <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MONTMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a3db98c488532c39cbf0d6ae19aa5ed">
              <SHORT-NAME>MSRA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MSRA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="289da850cbc83ecaaf09f6f2c9999066">
              <SHORT-NAME>MSRF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MSRF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e1351e200063c7f9147eb8898c049f2">
              <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MainBeamLghtOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d085b12dc71c3f3a9d7a76385c9ed38b">
              <SHORT-NAME>MainBeamLghtSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MainBeamLghtSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="055aaddb4eeb3fb490fa9beb46923988">
              <SHORT-NAME>MainBeamLghtSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MainBeamLghtSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4338f91f2ac3c349e128a8d8dd41e76">
              <SHORT-NAME>MaxAvlblTotWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MaxAvlblTotWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="461c6ffccb3d31d69a19e63c3c5afb24">
              <SHORT-NAME>MaxAvlblTotWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MaxAvlblTotWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ea6fed02bfd3045b0cf524bbf8792a7">
              <SHORT-NAME>MdOfPwrMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MdOfPwrMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="98122f52eb723808bef01cb0c58988df">
              <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MemParkngBtnRcnm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82ec1d8fa4f130588fa1a8ddd42e450f">
              <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MemPkngSlntPtrlEnbSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a53b16cb58b131f1a3bfaf1fb8af8ab5">
              <SHORT-NAME>MemPkngSlntPtrlEnbSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MemPkngSlntPtrlEnbSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2a81c620d2636a69a0fbd3b0039506b">
              <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MemPkngSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79e33171767e39fd9d34ec8182e7fac1">
              <SHORT-NAME>MemPkngSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MemPkngSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="556a47a7721b343ca775b61d7459caaf">
              <SHORT-NAME>MinAvlblTotWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MinAvlblTotWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="059a035eb3033336a4ee2bd7c6e98b35">
              <SHORT-NAME>MinAvlblTotWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MinAvlblTotWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="039c79b6e28933ce84717f8d2a17a188">
              <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MnvrngPntDistNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1866870454b3075b9759d367c016be0">
              <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MnvrngPntTypNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="432d57fe0a02355cad529421c50ad980">
              <SHORT-NAME>MouthOccludeStatus_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MouthOccludeStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d60e29509a933faa9811add0d95b2bcb">
              <SHORT-NAME>MulColBrkA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MulColBrkA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20b894969a35342e813d642ec3a81736">
              <SHORT-NAME>MulColBrkAvlblySts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MulColBrkAvlblySts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d7fa4a3319ee3f3b8151de8664345f04">
              <SHORT-NAME>MultColBrkAvlblySts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MultColBrkAvlblySts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="562f75eef18f3c66b3bd33c1d0701886">
              <SHORT-NAME>MultColBrkEnbA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/MultColBrkEnbA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf0b56729e863f13a95283491e93a94d">
              <SHORT-NAME>NFCAMAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NFCAMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a5eb454f3bc3704a3f49cc2a31e715e">
              <SHORT-NAME>NFCAMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NFCAMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b7df120708b31358a1f6524b4a46fdf">
              <SHORT-NAME>NFCSMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NFCSMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46c1a527048f3199ba242028d1ebc998">
              <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOACitySysMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b3b8b31541763f1786edaf8d803cf9c9">
              <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOADistDecMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="10fdc670ea20396fa8e4b5ac15b3d96e">
              <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAETCSetDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="77fea3ad425233d5b3cbf971eec63815">
              <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAETCSetSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8cda0bc327d35018bafedeb304f5711">
              <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOALaneSetDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="580cdf03ed9e380d902d435d906c544c">
              <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOALaneSetSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c816a6e604f73c3fa18122a43acdf060">
              <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAQukChgSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d7ac9bb779b737c8823416438036b6db">
              <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAQukChgSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="366bf370c89e39959b8999103486cf67">
              <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAReportSetDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4496d27a9e923d96b29084634af5367d">
              <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOAReportSetSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32c8f87a7ff33a07a9ef0629c87942bb">
              <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPCitySwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8fc48f9ee3953afa9b0d1a104f1aba72">
              <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPCitySwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="051a976b18f13d188c12ba1382a54fca">
              <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="efa5454396e03b8ea2ebef72fed8488a">
              <SHORT-NAME>NOPSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d40313dff7b431f3867de7b82378d0a3">
              <SHORT-NAME>NOPSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d02fd2e97c23d9cbe920a92e848298e">
              <SHORT-NAME>NOPSysMsg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPSysMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a1f90e778fe53a728909ba93a2cd2ac3">
              <SHORT-NAME>NOPSysSts_ZPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NOPSysSts_ZPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb3bba7ff01a31b69d56abdfbee2f60c">
              <SHORT-NAME>NSABacSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NSABacSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b8c7e2f36c4d33e78870cf573fdf3e3c">
              <SHORT-NAME>NSADisFucSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NSADisFucSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d177a6e2ca4834d4ac63d1390f32541f">
              <SHORT-NAME>NSAForSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NSAForSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8067762d10eb357b81005df32e76ddd1">
              <SHORT-NAME>NSAReqAVMDis</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NSAReqAVMDis</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ef096932c55350c839522c52cde9fff">
              <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarRoVslAssQuit</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02750e95d2bf3857a2502ad8bd6dd492">
              <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarRoVslAssSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b0e0f23cbcb391d91bf6e2c5033ee0d">
              <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarRoVslAssSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="53c767a940093152867a38721dcb1fff">
              <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarrowRoadBackwardSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7926c820ad13acf81fb4e321a89dbcc">
              <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarrowRoadForwardSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="50a9cf0ae43e39b597f506113d8c3819">
              <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarwSpcAstBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f07461a1598a3f4687b6b13573361b3f">
              <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarwSpcAstSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d729faa490873c26b150d00429813613">
              <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NarwSpcAstSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="feca9bbec1dd3c40924f71020455c06c">
              <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavCndSpdLmtVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a951ed7656e3b6593da176c2d0ba008">
              <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavCrntRoadTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f4972df70c33103b7e2ad56e03459a3">
              <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavCtryCode_ISO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67be2b22bddd3f08a7066aea0d3ddaa1">
              <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavDistFromFrtEleccEye</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82341602988d326bb78f184a0c25dfd3">
              <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavItvalSpdDetnDistRetDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="656e855a4d3137948d52ca6be858a10f">
              <SHORT-NAME>NavNewIconDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavNewIconDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="319e0704b6f4371aa5e0972ed07934ec">
              <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavNextRampOffset</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a5ab2165e4a3f0999c3b3b890e85b5b">
              <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavSpdLmtTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9fe1aac69c338cb94a93b984d67e8e7">
              <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavSpdLmtVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9390759f8f1c34f3a3e8a6ff9aaf4845">
              <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavSpdLmtValSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd075409e3533561b7a0f940a57d1a18">
              <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavSpdLmtValUnit</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da32c0a3bbe735b6b75d57ddc783a03d">
              <SHORT-NAME>NavSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NavSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5851747a296e3f7cbf8c1767885a2ac9">
              <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NonDirectDMSSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d404c77d5d93e3cac56553553408f3f">
              <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NonDirectDMSSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="15d5cf99576f377d8119ec01b12a9f98">
              <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NonDirectDMSSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9954da0cee133b2fa29d1ade1e9c974b">
              <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NorthVelocityRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b736c1b960d3557a38367d93ebafc2b">
              <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadBwdAssConfrmSwDscmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05f1a4cc10e7319c998cdaa2ea6bf94e">
              <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadBwdAssConfrmSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae85cefb727a3a2898bbd6a0c0892850">
              <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadBwdAssMesg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2963a92e7a6350daae50097fc44d6ff">
              <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadBwdAssSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac96b05028ea3d62b54e7a20ca134f44">
              <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadBwdAssSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4accf9644559322eb5df514301f86b65">
              <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdBtnDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="303315dbf5e23a17b6c1d1a5329a88b9">
              <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdCndNotSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="07c9c1e53453338bb795f11824c3fdbd">
              <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdCtlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4497f9f462fb368cbea46653e34f0b1e">
              <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="878919c685e531fd992b5232adf1dad6">
              <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDst360Req</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5272ccfdbb113941881dc98d2d5690c6">
              <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDstBtnDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a0a6035ade63fc983d1ee9209353f9d">
              <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDstL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a44e9925b67b3fbeb9af00ae7b24d885">
              <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDstR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e170cc459f2a3563af5da9b4c3d2b200">
              <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdDstTostDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="591320f19ac732fc8cabc006332b012b">
              <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdReDst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ec01426d4673b1eb679087db294cea0">
              <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="152620ddabb03cbfb802ac4c2466899a">
              <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4892cef7225362a9e21fa4ffc3dcafb">
              <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadFwdSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf263684249437d79ebf260491bc98ab">
              <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadsltReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6c0f63c3f1f3529a0d5ffb34908136a">
              <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/NrwroadsltSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29afbd2b838f3d86bbe0494fafadf229">
              <SHORT-NAME>OBC_ACInpFrq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_ACInpFrq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="486b743efa8139cbb4cc467b0bdaaae5">
              <SHORT-NAME>OBC_ACPwr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_ACPwr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="702f805b15bf3c379750417c09617efd">
              <SHORT-NAME>OBC_AcIptSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_AcIptSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0123359347c1389084890abed462e2f9">
              <SHORT-NAME>OBC_AcIptType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_AcIptType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e26c7d1c318e31eb94e6e16e74d0bff3">
              <SHORT-NAME>OBC_CCRes</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_CCRes</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="36f1203caee63ea79e89b121cd6d1c8d">
              <SHORT-NAME>OBC_CPFrq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_CPFrq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="970519a366623ba3b7373007b982fbac">
              <SHORT-NAME>OBC_CPVolt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_CPVolt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3d08fcfb688532d88569f260677408fb">
              <SHORT-NAME>OBC_S2Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBC_S2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7dacb801708f3398bd441c488bf7197f">
              <SHORT-NAME>OBMLifeTimeParmFromEsMaxLmt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OBMLifeTimeParmFromEsMaxLmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c28d9d258cd33f5f8c7ad56f09fcea20">
              <SHORT-NAME>OHCPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OHCPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29180d9c0bea3cf5b20860bcf7d38ce9">
              <SHORT-NAME>OMSBabyCareReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OMSBabyCareReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="50d8c054a5bc32ec890cebd69eac8d02">
              <SHORT-NAME>OMSSts_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OMSSts_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e5d48e591a583ee6a8b82a65d891d165">
              <SHORT-NAME>OMSSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OMSSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b4eb208701d3515a7c3a6388de43a81">
              <SHORT-NAME>OdoPriyPrcs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OdoPriyPrcs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a828b17e2f83050bfd9509adaa42db2">
              <SHORT-NAME>OdoPriyPrcsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OdoPriyPrcsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de11b852409c37c8b6ed2b836299f184">
              <SHORT-NAME>OdoSecy</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OdoSecy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b630c05a75b830ea9ba987ff0e7a4d40">
              <SHORT-NAME>OfbdChrgrNgtvSktTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OfbdChrgrNgtvSktTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88c80ce787c33b14a740ca2ad123dd6e">
              <SHORT-NAME>OfbdChrgrNgtvSktTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OfbdChrgrNgtvSktTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0dc07e252ab23087ada7b009dab1c322">
              <SHORT-NAME>OmsGesDetSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OmsGesDetSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d69fa149ec6348bb09ff126b9a660dc">
              <SHORT-NAME>OmsIlbRemSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OmsIlbRemSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b69319bac2433bddb70c10024dfac81f">
              <SHORT-NAME>OnBdChrgrAltrCrntInptCrnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrAltrCrntInptCrnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39b13ae41cfc37749f737c5021a5dba5">
              <SHORT-NAME>OnBdChrgrAltrCrntInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrAltrCrntInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ef02128f67d3d06b494e74f7111559c">
              <SHORT-NAME>OnBdChrgrAltrCrntK1OtsdVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrAltrCrntK1OtsdVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="724e2c4b859738f2bc1d937e6a3486aa">
              <SHORT-NAME>OnBdChrgrAltrCrntK3OtsdVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrAltrCrntK3OtsdVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b7af981d22a93d1e86fe9e7fa067577f">
              <SHORT-NAME>OnBdChrgrCtrlPilotPWMDuty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrCtrlPilotPWMDuty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f0656ebe9d53aecb0397f115cb3d9a2">
              <SHORT-NAME>OnBdChrgrCtrlPilotPWMSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrCtrlPilotPWMSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c1908607e19311a8416e01826b50046">
              <SHORT-NAME>OnBdChrgrHVILStsVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrHVILStsVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="788fd403b87b32d7a541cbccbec86ad3">
              <SHORT-NAME>OnBdChrgrHVILStsValV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrHVILStsValV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ea94bc22aed302a9692064881c26f71">
              <SHORT-NAME>OnBdChrgrL1AltrCrntInptCrnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL1AltrCrntInptCrnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="132ed421352a37a8a4fe1d53be79a0f5">
              <SHORT-NAME>OnBdChrgrL1AltrCrntInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL1AltrCrntInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78164494bb47386689da83f67beca64a">
              <SHORT-NAME>OnBdChrgrL2AltrCrntInptCrnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL2AltrCrntInptCrnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="542cdb05d5bd3ccea3b139f76d5f6c13">
              <SHORT-NAME>OnBdChrgrL2AltrCrntInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL2AltrCrntInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f89eb938ac063837b72eeaa6a56e07ff">
              <SHORT-NAME>OnBdChrgrL3AltrCrntInptCrnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL3AltrCrntInptCrnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="468f7aa9d3ca3d2b97218c4fb4fead39">
              <SHORT-NAME>OnBdChrgrL3AltrCrntInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrL3AltrCrntInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="faae0ed8a2e337e4b059e543190a16a6">
              <SHORT-NAME>OnBdChrgrLastWkup</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrLastWkup</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d54fabd1d0c436d58a96ddc2fbf5c852">
              <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrOptAltPwr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="348697c25a5b339598995831be8e3c09">
              <SHORT-NAME>OnBdChrgrOtptVolV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrOtptVolV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8784929e8e693239ab2adf3730e7089b">
              <SHORT-NAME>OnBdChrgrSktElecLckSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrSktElecLckSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a197b4948d0033689d065b9f9a573160">
              <SHORT-NAME>OnBdChrgrSktElecLckStaV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrSktElecLckStaV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6eb3ff69e7113ec387be7fc68ed53083">
              <SHORT-NAME>OnBdChrgrSktPstvSnsrTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrSktPstvSnsrTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0e1521ffa0053821826d65fdc3dd7109">
              <SHORT-NAME>OnBdChrgrSktPstvSnsrTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrSktPstvSnsrTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fe95282e2bae3cce849debdc5de578a1">
              <SHORT-NAME>OnBdChrgrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c6ae91ec75930e0808568ae24d5dd93">
              <SHORT-NAME>OnBdChrgrWkup</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnBdChrgrWkup</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3b562c3331438979523dde6025cd47b">
              <SHORT-NAME>OnbdChrgrAltrCrntInptHVCrntLmt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrAltrCrntInptHVCrntLmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78a8f3e3c27032e3b78eb72d5267f8cc">
              <SHORT-NAME>OnbdChrgrOpngMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrOpngMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a2ea43edfae3543890f250bea14208b">
              <SHORT-NAME>OnbdChrgrOtptCrntV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrOtptCrntV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6279c2bcad43fe399f4149a8b3f5ac9">
              <SHORT-NAME>OnbdChrgrOtptCrntVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrOtptCrntVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8419331904cc3a35aa9ca58cfeb8373e">
              <SHORT-NAME>OnbdChrgrOtptVolVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrOtptVolVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a314e8a831103899840322f8a48140e2">
              <SHORT-NAME>OnbdChrgrSktEleccLckEnable</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OnbdChrgrSktEleccLckEnable</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57131ff79a43373a80958bc7d060d302">
              <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemCrVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="074eeb36f7c7322f8b7257371228163b">
              <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemCrValMsk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ba04f456b273e70a56f3fc23f30a6b6">
              <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemCrValV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88682d338de63ae884b1632fb6a599c3">
              <SHORT-NAME>OtsdAirTemPtEstd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemPtEstd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1f022ea5b30371094915d1b7f2f4e85">
              <SHORT-NAME>OtsdAirTemPtEstdMsk</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemPtEstdMsk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba3e4db0ad633bf3b48435445ca297e8">
              <SHORT-NAME>OtsdAirTemPtEstdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemPtEstdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d960b10fd4534c5b0121f94fb7e6cfb">
              <SHORT-NAME>OtsdAirTemVDA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/OtsdAirTemVDA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2512b4eae3d835a5be5a5a009eba0d47">
              <SHORT-NAME>PDCPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDCPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cee3c96ddbd7384f8abddd555f413b21">
              <SHORT-NAME>PDCSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDCSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d330d75707a03d789afe0b6c96ec6ed5">
              <SHORT-NAME>PDCSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDCSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dfdef0c1d205326185e3718f9506b901">
              <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDSysKeyPsAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="510cd4c65368352b9f629bbc36c07eaa">
              <SHORT-NAME>PDUHVILSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDUHVILSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="28b1db81698d30bbaf898f5b1bf323f9">
              <SHORT-NAME>PDUHVILStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PDUHVILStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="143e6b36818a3cbbb3fb41a0d4caaf25">
              <SHORT-NAME>PEBSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEBSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef116e757d8138a6a7241a669e72ffb8">
              <SHORT-NAME>PEBSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEBSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="545ef2d79e8030049e58198a1f58b09d">
              <SHORT-NAME>PEBSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEBSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="857d889e6f153b33acbcc1beda9fddc9">
              <SHORT-NAME>PEBSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEBSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5dd92a6644ea3fe7b4578f1125932e77">
              <SHORT-NAME>PEBWarngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEBWarngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f97c5c4eaf5e3fe99855d1e1cf057c33">
              <SHORT-NAME>PEUMotADampTrqCmdd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotADampTrqCmdd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9cf1e067f0d83b189da36dae02f9cf01">
              <SHORT-NAME>PEUMotAMdAch</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotAMdAch</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae591c1b80ce303fb42da6716ddd2d10">
              <SHORT-NAME>PEUMotASpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotASpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="15d9f310955433e7b54aef6077461dec">
              <SHORT-NAME>PEUMotASpdSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotASpdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="438a63cf3b8730efb759a12a510cbd3d">
              <SHORT-NAME>PEUMotASpdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotASpdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8a1230f7c7935b9998bb634bb183afb">
              <SHORT-NAME>PEUMotAToqAch</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotAToqAch</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4331352885bf3033986a381310cb8849">
              <SHORT-NAME>PEUMotAToqAchV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotAToqAchV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1b80e11db363b9f87d718392cbb71fc">
              <SHORT-NAME>PEUMotBDampTrqCmdd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBDampTrqCmdd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f6a8cfa3dd5335fbe46e7f0f6ab1927">
              <SHORT-NAME>PEUMotBMdAch</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBMdAch</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3cfe31c312973f3680f3f8dae659a0eb">
              <SHORT-NAME>PEUMotBSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f621b38e27933a20b1011a02cc453394">
              <SHORT-NAME>PEUMotBSpdSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBSpdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32de6d92d6363f0b9d3240da727a6f76">
              <SHORT-NAME>PEUMotBSpdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBSpdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b353a35e8763508b994eb79a23a7371">
              <SHORT-NAME>PEUMotBToqAch</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBToqAch</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c209e854309336679e27d48c2d5f71a5">
              <SHORT-NAME>PEUMotBToqAchV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEUMotBToqAchV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f4b9239a08a437108bcacccc86146db1">
              <SHORT-NAME>PEU_10ms_Group25_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_10ms_Group25_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f38ea77c160a32c7810a1697052582d9">
              <SHORT-NAME>PEU_10ms_Group25_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_10ms_Group25_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8c19607a529d391d97ad9dd7c153f4ad">
              <SHORT-NAME>PEU_10ms_Group25_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_10ms_Group25_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01be5c4c9ca43a7b8a3a1486eea879c7">
              <SHORT-NAME>PEU_10ms_Group25_Reserved147</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_10ms_Group25_Reserved147</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c84d45e054e83a67bac0edf038cb293e">
              <SHORT-NAME>PEU_10ms_Group25_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_10ms_Group25_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="863f03ba2b0130e0a6d995eab96e5a61">
              <SHORT-NAME>PEU_ERAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_ERAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5085b37879bf33e493f6d740052b0c43">
              <SHORT-NAME>PEU_ExtdAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="807fcca7f537306f8a5e192dc96c7520">
              <SHORT-NAME>PEU_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f79089095a131f391f22eb8849d7a82">
              <SHORT-NAME>PEU_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7dd7a6e239737f59cd1cbe4074a8916">
              <SHORT-NAME>PEU_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4600837beab93369b12d494f3195650e">
              <SHORT-NAME>PEU_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="444a9194574131e9906ca8135d802ba1">
              <SHORT-NAME>PEU_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99541448b66c33c98308309e34e260c9">
              <SHORT-NAME>PEU_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4d7af96da49238688494d0a4fc9f2f20">
              <SHORT-NAME>PEU_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd43f986b3c43986b86246f7f8d128a5">
              <SHORT-NAME>PEU_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4b08ea177ab309e93e50000ab0b03e9">
              <SHORT-NAME>PEU_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c87cd34114a43471888c54c18f4aee87">
              <SHORT-NAME>PEU_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2a4347104e933bc9b5ee01490916e89">
              <SHORT-NAME>PEU_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="684742ed204f36dbb4f31a211716766b">
              <SHORT-NAME>PEU_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3675abaaab7d369a8c92d000bfc11fa6">
              <SHORT-NAME>PEU_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4648541438083b449014e5a4428624ef">
              <SHORT-NAME>PEU_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba4f90adf9263b5982d0d7a5472eb5eb">
              <SHORT-NAME>PEU_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64367a6ab5313968b856058967fce74c">
              <SHORT-NAME>PEU_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="812edafe79973bcb921f81b59f0c1d74">
              <SHORT-NAME>PEU_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b7754d0c9e53d8ab24f99b99655aced">
              <SHORT-NAME>PEU_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1cd726b7ca80389d9a19536cebd3dedf">
              <SHORT-NAME>PEU_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef344d48c7ac3da7a6eb7736f0810989">
              <SHORT-NAME>PEU_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cfa7cd07855c3c85a7bc02ae76f283b6">
              <SHORT-NAME>PEU_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3258915cbc0e36d58c68040c4fc93006">
              <SHORT-NAME>PEU_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d59ab5e93059381992888f82ce0e0e27">
              <SHORT-NAME>PEU_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="670e92b0a0aa35489d28b8223088f76c">
              <SHORT-NAME>PEU_SFAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PEU_SFAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="41d5152fc589380983e418519218f36c">
              <SHORT-NAME>PICM_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0222fa6169bc38d8b077656f3e0abeff">
              <SHORT-NAME>PICM_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b698854b43a38f5904bf561cfcf2905">
              <SHORT-NAME>PICM_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="74a512db55653389875df7437e01b79c">
              <SHORT-NAME>PICM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05d446a99193385d8dad8079225fcf9d">
              <SHORT-NAME>PICM_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="19d256aa21053415848e2e0425cf9127">
              <SHORT-NAME>PICM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7206109ba5e53df7938c419cd249a2f5">
              <SHORT-NAME>PICM_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f0db22be1dfa3fd4895ab07def1ce412">
              <SHORT-NAME>PICM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e44903a38d2c3094b8cbe74b95dde82c">
              <SHORT-NAME>PICM_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d27c4e29bd537429b9e911e797b78eb">
              <SHORT-NAME>PICM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13dec8eaa2eb3f7bbbaae38e88ba92da">
              <SHORT-NAME>PICM_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9463e0c6a55d3f03a63a1e1e5797f487">
              <SHORT-NAME>PICM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94db4f362e233950b56689fbefdeecaa">
              <SHORT-NAME>PICM_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a620d6147f832199bb17c81bd9050b0">
              <SHORT-NAME>PICM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95a9bf5680be34be8bd3cedbb9f46978">
              <SHORT-NAME>PICM_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e46365d5a4be318fb5272b08e008eef7">
              <SHORT-NAME>PICM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f70e3aa681a3813ab4569972f5a1285">
              <SHORT-NAME>PICM_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b10c295cf50e391c92403da28459200d">
              <SHORT-NAME>PICM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed799fa158253dff8254b17f67ac411c">
              <SHORT-NAME>PICM_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="73a502872018334c9c93d9ad272652b8">
              <SHORT-NAME>PICM_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="901cc0928e25329db266ab024f95b502">
              <SHORT-NAME>PICM_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c4a914a877a836eab50e9ed3cea514b1">
              <SHORT-NAME>PICM_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICM_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72c962da4d9c3dcc978eebb78584b6f1">
              <SHORT-NAME>PICU_10ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f313f3f30503c7189f13ddc5b39f0f0">
              <SHORT-NAME>PICU_10ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bca6643bac033a23b6ab925d93bf802b">
              <SHORT-NAME>PICU_10ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="43c33bb2eb733028b6935e6a5d5e2509">
              <SHORT-NAME>PICU_10ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72b88b193eae3f9186a57d618905dbc6">
              <SHORT-NAME>PICU_10ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0981a41dec2d348aa212c2a99dcedc5c">
              <SHORT-NAME>PICU_10ms_Group03_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8324a92fc62131c5862e606a9843fe42">
              <SHORT-NAME>PICU_10ms_Group03_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ed3c467a574311a9800a956c73fda17">
              <SHORT-NAME>PICU_10ms_Group03_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1355acdd2ba93e0295b26b739cc88f4e">
              <SHORT-NAME>PICU_10ms_Group03_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a94665980eaf37c6874138a29259493d">
              <SHORT-NAME>PICU_10ms_Group03_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e6c541e79acb3ba486e0babe5d2ce631">
              <SHORT-NAME>PICU_10ms_Group03_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group03_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab642074bd093352a92f06272ecc20dc">
              <SHORT-NAME>PICU_10ms_Group23_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group23_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bdc31399970f356f95124ea30107a58c">
              <SHORT-NAME>PICU_10ms_Group23_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group23_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24ed8ad48dcb3bffb73a637aa758052a">
              <SHORT-NAME>PICU_10ms_Group23_Reserved18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_10ms_Group23_Reserved18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5574e4e02993609b9451a4e76d289be">
              <SHORT-NAME>PICU_20ms_Group11_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b344e620659936e58779a8c6a95e5bd8">
              <SHORT-NAME>PICU_20ms_Group11_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63121bda57343e30afe48606e672b2f9">
              <SHORT-NAME>PICU_20ms_Group11_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c78a778475b3fd99322f463daa97f47">
              <SHORT-NAME>PICU_20ms_Group11_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a48da30d676937d2beb762643806f689">
              <SHORT-NAME>PICU_20ms_Group11_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="730659a53e3a3c9484e4431a0a19e62f">
              <SHORT-NAME>PICU_20ms_Group11_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06287d0caf1136f1bb88c9f77038e907">
              <SHORT-NAME>PICU_20ms_Group11_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59ecb853c3643e4580aaa2c8914a98d5">
              <SHORT-NAME>PICU_20ms_Group11_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f7ced66e38e3ef299b323f888ad6d5a">
              <SHORT-NAME>PICU_20ms_Group11_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d0d0ca73618a3a8cad74224ab6ecad21">
              <SHORT-NAME>PICU_20ms_Group11_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5c8d16eeed0344d88b5129a9b09bf1f">
              <SHORT-NAME>PICU_20ms_Group11_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_20ms_Group11_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="26f9b7504a853fcaa6d1be815707af73">
              <SHORT-NAME>PICU_ExtdAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b027c6be3dd83359aa2d5eeb0066f76b">
              <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PICU_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4fe8ee61a24e345c8eb2fe23bf7e511d">
              <SHORT-NAME>PMDCIlgclCal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PMDCIlgclCal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2c5605035ccf30f29b4745edefe16db0">
              <SHORT-NAME>PMDCIlgclIdficn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PMDCIlgclIdficn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29eff94bcf5734df8449156892dcd1e9">
              <SHORT-NAME>PMDCSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PMDCSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e030bb56e5b135f0a45e40f12962eb04">
              <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngDirAvlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79226a8a04f43a7aa1eb0dfcd7c5bdbe">
              <SHORT-NAME>ParkngDirSw</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngDirSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ba751af7e8f30dab2399c68a60e9843">
              <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngDirSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5fd4f732f6433aa9a7b5291c8025dffa">
              <SHORT-NAME>ParkngEndDis</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngEndDis</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05fa621056203fe89bd89c8d56baa3df">
              <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngInPrgs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f39e14d91c09303491c79708927c53df">
              <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngNCPAvlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e0a2b72cdca037bc9774598c19be1101">
              <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutBkCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d9f251fc55b3e358117c34323ddabcb">
              <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutBkLCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4277a3c847ed384f91e2b6258f2a78c0">
              <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutBkRCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24aca580da9d384d8281e3c39acd2dc5">
              <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutDircnSelResult</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f881e0190643524adad5072165a2a9c">
              <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutFLCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="38acb9047b93305fb62f60bda2a19edd">
              <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutFLParllSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c11b4f30c70632448d542f614b79bd17">
              <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutFRCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae22fae156f83ad8a609b3a55406bdab">
              <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutFRParllSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a792a8a446343c50b9d7c101d000f12a">
              <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngOutFrtCrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c789bcef3ff437318bbd6d53dbaa846b">
              <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngSlotFindSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5f67f36c423a3226988930684895c522">
              <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ParkngSpdSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e3a9914aa7fb34eabb39cd639710e6fe">
              <SHORT-NAME>Parkngslottype</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Parkngslottype</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c3f4569da1e3adc94c6b63a755b6c92">
              <SHORT-NAME>Pdop</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Pdop</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8f7349f647635388953cc2149d9a091">
              <SHORT-NAME>PedtrnProtnSysDplSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PedtrnProtnSysDplSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8185598b3b053deabd7a4235cd076439">
              <SHORT-NAME>PedtrnProtnSysDplStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PedtrnProtnSysDplStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c99d581ca5f3e77b5d75916a1169593">
              <SHORT-NAME>PedtrnProtnSysIndrCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PedtrnProtnSysIndrCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="077fa41dcd3a3f5b88c7d9c9a1dfc8fb">
              <SHORT-NAME>PfTrTapUpDwnEnbSwSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PfTrTapUpDwnEnbSwSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e84d6618df0434d8a886cec6d26f120b">
              <SHORT-NAME>PfTrTapUpDwnSecySwSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PfTrTapUpDwnSecySwSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f969f10c52bc32f88e0438b25f348c8c">
              <SHORT-NAME>PfTrTapUpDwnSwSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PfTrTapUpDwnSwSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f489cb5dacf3f28a186f96c2942c091">
              <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysADASFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7fb898ef8dc83ecbabccb6d290b9ae56">
              <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrF1FltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="554bd53d5905307d854abef475100753">
              <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrF3FltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b3f20ad17d0a3901871d958a6aca9850">
              <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrFLSFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0eb467bccf0436638e55b1a1adaa56c6">
              <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrFRSFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a65c48f494fb30cd978fdea15ad3d458">
              <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrRFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf102c4a31523e97aeee19016464966b">
              <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrRLSFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a7bf4630e0e3f6f8d6c19c46b1c2cfd">
              <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysAVCamrRRSFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67269b95b25c3a43ac57b8a3f5f9d800">
              <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysFDRFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5b44105dfaa3cfc9c3b5a5863cfaf02">
              <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysFLIDARFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="521d680d235c3d8394e0d72e15d6e25d">
              <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysHDAVMCamrFFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9189c196a3b732948824f4e88a525b76">
              <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysHDAVMCamrLHFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2fe7b4aada213b7ea14f8278a808acc5">
              <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysHDAVMCamrRFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8c046dab151a34108b2889eed99bd495">
              <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysHDAVMCamrRHFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9473e66cbe3e3a319686efe5d4228ded">
              <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysLFSDAFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f1384a673e0d306085c6f1ec37db9780">
              <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysLHRDAFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="736ff4787fa03efe911ae591f7931508">
              <SHORT-NAME>PilotSysMsg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7eccc304dda338eaa5e0b2402d245d86">
              <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysRFSDAFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b7331c73fad2354495e10d245b62a20d">
              <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysRHRDAFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c6ab644c6103081bbf0f83f021305f7">
              <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotSysUSSFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="43d630948c5837b49fe48d91aa141d00">
              <SHORT-NAME>PilotTkovMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PilotTkovMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a91be257e4b63c09a78c3f1b060eab06">
              <SHORT-NAME>PitchRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PitchRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a8988ec4f0dd39b7b3ba6d4ca40ea99b">
              <SHORT-NAME>PitchSigma</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PitchSigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b8bd03202d63c329e4a56bbdd3699fd">
              <SHORT-NAME>PltEPSRdWhlAngReqSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PltEPSRdWhlAngReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ac30969b5ba37149e51c02f67676453">
              <SHORT-NAME>PltEPSRdWhlAngReqStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PltEPSRdWhlAngReqStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bba14379713e3238b3d30406b0caef62">
              <SHORT-NAME>PosALCFailed</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PosALCFailed</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed0b48fd6e9d3c29bd2a214d9520da32">
              <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PositionAttitudeStatus</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbe5d95e21fc3b0cadb8e226d942548f">
              <SHORT-NAME>PriySSBA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PriySSBA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6b3eb052574e3ec89a892dabebe2bed5">
              <SHORT-NAME>PriySSBAV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PriySSBAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b44b174c901537c59f741937a6d98406">
              <SHORT-NAME>PrkgDstCtrlSwResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PrkgDstCtrlSwResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ce0c81c63453a8d9f6e63e60c96d0b7">
              <SHORT-NAME>PrmntDTCDrvngCycCrtra</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PrmntDTCDrvngCycCrtra</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f377776f54f356782f81efcf3ec91f2">
              <SHORT-NAME>PropSysA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PropSysA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ad364f0abed374888eb769504ecec6b">
              <SHORT-NAME>PrvOutSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PrvOutSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f42ddc8cd3083516bc03a5fa1fcd49ca">
              <SHORT-NAME>PtACCA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PtACCA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e28681fc823c342b8b67739aeb164bee">
              <SHORT-NAME>PtACCToqReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PtACCToqReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d97f805df5b033bf9abffa71b3a203a1">
              <SHORT-NAME>PtAPASts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PtAPASts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ef046ec355d3c7882a672c398f1c5fc">
              <SHORT-NAME>PtAPAToqReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PtAPAToqReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="878ca8b8a2003bea982a49242ba1b224">
              <SHORT-NAME>PtHVCntarReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PtHVCntarReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="af970e7cd7d035058d45f29e2357ea55">
              <SHORT-NAME>PutSmrtKeyToBkupPosRmnr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PutSmrtKeyToBkupPosRmnr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="25a4110b8636367e8e694a662fdd886d">
              <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrDMd_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3cda97096a93304db9cea97e75f7fa47">
              <SHORT-NAME>PwrLftgtClsSwtActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrLftgtClsSwtActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91aada0b64dc35b98d354755d6179098">
              <SHORT-NAME>PwrMdCtrlResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrMdCtrlResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2341ec6d9f8e3833bda63a4febdf639b">
              <SHORT-NAME>PwrMdExtrCtrlAvlbl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrMdExtrCtrlAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c5d2d34523763e23be097942e3301ad8">
              <SHORT-NAME>PwrMdMstrAccryA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrMdMstrAccryA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f08b60d544c3a3aa56b020fe967635a">
              <SHORT-NAME>PwrMdMstrRunCrkA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrMdMstrRunCrkA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a55f3806eb1385f82db20745d4a939e">
              <SHORT-NAME>PwrReq_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/PwrReq_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7aae428de3dc321c932f198747a1ecf7">
              <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RAAlrWorDis</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="184921b212d733dcb10c22c0d7338788">
              <SHORT-NAME>RACtlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RACtlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ffe4d13bd223867a41f5765f6091449">
              <SHORT-NAME>RADSSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RADSSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62420081267833e0a9b510fb6301a7e1">
              <SHORT-NAME>RASysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RASysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a2b2361ce30c3a858fabbd44a230ec96">
              <SHORT-NAME>RBSDAndLCAWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RBSDAndLCAWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8af684f4c8c3e929d203ce178482683">
              <SHORT-NAME>RCPDDlyTimeSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RCPDDlyTimeSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7cf41f2674933432895ea683e2cceb91">
              <SHORT-NAME>RCPDMdSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RCPDMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="17514cfc36e6300e99568bcb199239bc">
              <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RCTSysSelReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f4796f1661538039efe79606cf881c1">
              <SHORT-NAME>RCTSysSelSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RCTSysSelSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5c3002987973220abdef01d656beb5c">
              <SHORT-NAME>RCWSelReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RCWSelReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="22c7df38c56a3f4bad2cc73892066389">
              <SHORT-NAME>RDASwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDASwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1bf7fcf3baaa35c4a1d7c4de3aac1fd3">
              <SHORT-NAME>RDASwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDASwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="87554f0cb408319c8609d8f7843d83a6">
              <SHORT-NAME>RDASysSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDASysSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4dfc6abd8b20387790bd17f5c0590337">
              <SHORT-NAME>RDOWWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDOWWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a726f7ddffe39cd86cb317ef4833838">
              <SHORT-NAME>RDayTimeRunningLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDayTimeRunningLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="09379a60a78b3683bcd53f86f00ecb69">
              <SHORT-NAME>RDipdBeamLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDipdBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c71f3520f4d33f03b099aad16cb0fc7f">
              <SHORT-NAME>RDircnIO_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDircnIO_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7eda8c641e636d79c5283daa8093a0a">
              <SHORT-NAME>RDircnIndLghtF_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDircnIndLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2803739f7a85327893d695938cf27d48">
              <SHORT-NAME>RDrvnWhlRotlDircn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4dd8a9d78604346c99a4e08c12ecb2e5">
              <SHORT-NAME>RDrvnWhlRotlDircnSdslSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDircnSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da9f833eca743115b97c5e65076b10e9">
              <SHORT-NAME>RDrvnWhlRotlDistPlsCtr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDistPlsCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51f7101a1e4230bfac5f5221fa9f7e00">
              <SHORT-NAME>RDrvnWhlRotlDistTRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDistTRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba80c80fbc5e32238336fa36b544d33b">
              <SHORT-NAME>RDrvnWhlRotlDistTmsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDistTmsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5bc1a7afb511363bb3969262f118192b">
              <SHORT-NAME>RDrvnWhlRotlDistV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlDistV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd378f5460313ea080a6e051255d15ab">
              <SHORT-NAME>RDrvnWhlRotlRstOcd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlRstOcd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02f87966e3923191a69eb0f29b84bdda">
              <SHORT-NAME>RDrvnWhlRotlSeqNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RDrvnWhlRotlSeqNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc9cc5a31672341da931e3ad2c10d002">
              <SHORT-NAME>RFCTWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFCTWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6668e50f2be63d02a35d6a3b6f7f2978">
              <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFCTWrnng_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4fffd3c8bf833608a2af80d2b07e81d">
              <SHORT-NAME>RFSDA_20ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6667ddf14a093ef6bd7497c5a4601f53">
              <SHORT-NAME>RFSDA_20ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a05abfec46734c19355d1a369eec878">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6ea29f296203a3abef223937206974d">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bf9573e8a3f320aa6f62f37b6bb4482">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c55874334bdb3889af7af9821ae193a7">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69d164e1d18a3d20887b120f2d8ed0cb">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f78a06dc5ab73b49bda8b8411149ab6b">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f58fa91c09703c37824d1fc4c5c9546b">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a1a3af79bda3c26ac8a36be34cc7cab">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f95788fced0356d8935f1d8a89f63fb">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96e219145b96388fae5b4c9fad40a749">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4b46023fa0a3297ae9c1dbde40a6e61">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c589cf68b6b33f5adacae520179ff67">
              <SHORT-NAME>RFSDA_20ms_Group02_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_20ms_Group02_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcc72905c302363eb31f09d0a1b09071">
              <SHORT-NAME>RFSDA_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62f052d26c5a3f4aa2139a0b4de5a180">
              <SHORT-NAME>RFSDA_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4db416a78b5f3800867a3984e0b9fb7e">
              <SHORT-NAME>RFSDA_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="717a878abaa4372cbc9ff71e022e396d">
              <SHORT-NAME>RFSDA_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="969fa2bad7c13cafb8234c8d3086c73e">
              <SHORT-NAME>RFSDA_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5dbaeb636c79354bbea64c7e48341348">
              <SHORT-NAME>RFSDA_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b97c0c929b6317289d2e2095e5cbbea">
              <SHORT-NAME>RFSDA_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1125ff6c660536d68a53648137ee3903">
              <SHORT-NAME>RFSDA_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e9ce23b5204c3d6da46623c49d03d297">
              <SHORT-NAME>RFSDA_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d7a34603da430619a1c707be707edc7">
              <SHORT-NAME>RFSDA_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="df93645ccd3f3223b219d5756efd91d9">
              <SHORT-NAME>RFSDA_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RFSDA_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f707c2f01713adb9f6b626b39e04c42">
              <SHORT-NAME>RHAmbtLampPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHAmbtLampPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48b313fa4fcc383e88d012feef7e5c6a">
              <SHORT-NAME>RHMPWCAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHMPWCAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46c877ef55873d1fa96c59c9f4c7c981">
              <SHORT-NAME>RHRDAAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDAAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa072e19b29330aa96a3e1e2f9ea3217">
              <SHORT-NAME>RHRDA_50ms_Group04_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="790b5f7f49d636379a339c0f98c5270a">
              <SHORT-NAME>RHRDA_50ms_Group04_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef5e5b6cfd8634728049f86c59f2f55a">
              <SHORT-NAME>RHRDA_50ms_Group04_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4565c4c8527e3982ba7c1689dbd8737d">
              <SHORT-NAME>RHRDA_50ms_Group04_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4103178ad8fc3d549bd8c4771896f591">
              <SHORT-NAME>RHRDA_50ms_Group04_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="821612887fbc3573b8f5017f8c60266e">
              <SHORT-NAME>RHRDA_50ms_Group04_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_50ms_Group04_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d24892fc0db436f2ace7a4a8d370e6c7">
              <SHORT-NAME>RHRDA_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="07e862bdfd3d314781a7206e9863cc3c">
              <SHORT-NAME>RHRDA_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0942b4862d8333508510f85fa5b91420">
              <SHORT-NAME>RHRDA_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="086f7a52b42735079977bb49dcfabdb8">
              <SHORT-NAME>RHRDA_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b286d6611248331eac6d568b2ad3475f">
              <SHORT-NAME>RHRDA_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2c907adf96d30b0905886df922d59fa">
              <SHORT-NAME>RHRDA_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dd2de4870d953db1b0f79c2d683d95cd">
              <SHORT-NAME>RHRDA_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f98bf5ccabe35f88f893d03b6736abd">
              <SHORT-NAME>RHRDA_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="655ea9141fb13171b8d0dc1668794af9">
              <SHORT-NAME>RHRDA_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b1f53dccb370324489984458dd8d0757">
              <SHORT-NAME>RHRDA_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="74f36e803a223dd492bd0ee0d8198837">
              <SHORT-NAME>RHRDA_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb6f0d68685b3d47a98227e36f67cf81">
              <SHORT-NAME>RHSwPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHSwPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ed8b6e20a233cdaacf217d247e8a40e">
              <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f626b361ba23cb3b35ca55c17b7b0d6">
              <SHORT-NAME>RHZCUIgnDiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUIgnDiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5346a50395d83f509377066e18e482bc">
              <SHORT-NAME>RHZCUIgnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUIgnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ffdea5a89b653f87b98e6228930b64fa">
              <SHORT-NAME>RHZCU_100ms_Group10_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f28dff8231d399db41ee8f07d219bc4">
              <SHORT-NAME>RHZCU_100ms_Group10_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="031519da90613f5aaab7e4636638458e">
              <SHORT-NAME>RHZCU_100ms_Group10_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d72941dfc1693a4faa9c200bb89c12e2">
              <SHORT-NAME>RHZCU_100ms_Group10_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1db9938f970430219064a5390fa8fc69">
              <SHORT-NAME>RHZCU_100ms_Group10_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="922183a1236535d0b12649f0ce624a9b">
              <SHORT-NAME>RHZCU_100ms_Group10_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="758d9fb2902832a699be490825852911">
              <SHORT-NAME>RHZCU_50ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1e61a2bb5a2f3d2aa18bb27308517e6c">
              <SHORT-NAME>RHZCU_50ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a5284853e8043cae818a32724cd324ff">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3372db4afba037168713c63da9fd2bd9">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="459250908b8030e09868a8a36f6c3589">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f4e224c28c853f1bbe93d6d4ea6878ea">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02ccab993a8d34a58fd6b96526d71339">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6aeb90e14f463270a519e3ae231cd4ed">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1f4c5a1883c31358c9b9a146ff4afa7">
              <SHORT-NAME>RHZCU_50ms_Group01_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3384d23afbf63e229661d4a3b5a8cf6d">
              <SHORT-NAME>RHZCU_50ms_Group27_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24424f026ceb36229b20dfb965dc69b7">
              <SHORT-NAME>RHZCU_50ms_Group27_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="940b71e9b8dc3892a66ed3a4bdd9334f">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e3e3f47fb40d3c9cb14167ff467026e9">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb579e9f3cc1332997bb5f34600755d2">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="684f99ce43443af283df1b2c39c3d310">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08103dbd19763c93954bedd8ef4b9409">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6762943d01b3c69ba238af5c08e4f00">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b81536ad8e7d30cca4275a3a5533107e">
              <SHORT-NAME>RHZCU_50ms_Group27_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7dc93d8d6f3937d48ac2371c196e247c">
              <SHORT-NAME>RHZCUeFs1DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs1DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6302a596dbad3481ba67a3287253b2e8">
              <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs1Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61e4f42e2e653a179a9c19867cf0233d">
              <SHORT-NAME>RHZCUeFs2DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs2DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4638039dc3e3b978d72d1093faf1138">
              <SHORT-NAME>RHZCUeFs2Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e9850c645ec35adb4d8624933aabfb3">
              <SHORT-NAME>RHZCUeFs3DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="87e9e10c05673fe797c42f9acbc85abe">
              <SHORT-NAME>RHZCUeFs3Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96e11c6f1f113e2895dcee4eceb1e71c">
              <SHORT-NAME>RHZCUeSw10DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw10DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a992660550d3ae092024feebe6ab20a">
              <SHORT-NAME>RHZCUeSw10Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw10Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="650b1c124c1630c085a199092a25c7f2">
              <SHORT-NAME>RHZCUeSw14DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw14DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6181ce8443ef3b11b01e29bdcb809560">
              <SHORT-NAME>RHZCUeSw14Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw14Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="242c2df4b38430868a0af5f0700cc444">
              <SHORT-NAME>RHZCUeSw31DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw31DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5180f90d5afe32e6b94f8446886b8c77">
              <SHORT-NAME>RHZCUeSw31Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw31Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a5fa90edb4fb3de1946916a29913953c">
              <SHORT-NAME>RHZCUeSw33DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw33DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef03eaf2fabb37bdba62e884cf5f3870">
              <SHORT-NAME>RHZCUeSw33Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw33Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5843853400dd31309b8b8a56bb1554f0">
              <SHORT-NAME>RHZCUeSw34DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw34DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5bc446f54a113a44861538be81c3bfa5">
              <SHORT-NAME>RHZCUeSw34Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw34Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="724043575b45327c9a64cab627325f44">
              <SHORT-NAME>RHZCUeSw37DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw37DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="27f061339550373fb2fe35979cbdcef8">
              <SHORT-NAME>RHZCUeSw37Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw37Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa9a552a601b34ef8aa7aeb9a3d43cc9">
              <SHORT-NAME>RHZCUeSw3DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e9238e1700c435979e32c8cc7ca34909">
              <SHORT-NAME>RHZCUeSw3Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f3f01fec19d3e9bb32250f9ae601d88">
              <SHORT-NAME>RHZCUeSw41DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw41DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b92c4820c01b33439c87e183df3d5b8f">
              <SHORT-NAME>RHZCUeSw41Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw41Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="572f862652373acbbb16c701f871a3fb">
              <SHORT-NAME>RHZCUeSw42DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw42DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e52c6275a155370c95b46640a49ec835">
              <SHORT-NAME>RHZCUeSw42Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw42Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6fe459d7b3923634858228449821cb0d">
              <SHORT-NAME>RHZCUeSw43DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw43DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b19195b82e13dc792478655b55f9a0a">
              <SHORT-NAME>RHZCUeSw43Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw43Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc5cef406f7132fdace1e4ff9d401fd4">
              <SHORT-NAME>RHZCUeSw9DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw9DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8fce0ca857a43a4da5451bb0f5526e4d">
              <SHORT-NAME>RHZCUeSw9Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw9Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce8980d72e1735cda7f7198b59d044f6">
              <SHORT-NAME>RHandAntFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHandAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b41b5fb9ed5360594c6d8068465e17e">
              <SHORT-NAME>RLDircnLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47e93ed96f22334fb4a14ac4cc3099c6">
              <SHORT-NAME>RLDircnLghtFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8db097c8854336919bce3b599f437ea0">
              <SHORT-NAME>RLDircnLghtFltsts_HW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtFltsts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc1fe83b4a363a53953cb6ef028bbb5b">
              <SHORT-NAME>RLDircnLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="705a3a050cbd3527a33ecddc1b816cd3">
              <SHORT-NAME>RLDircnLghtSts_HW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3329f09e571b3dd299d8170a96158836">
              <SHORT-NAME>RLDoorLckSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDoorLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ade137d0c4d3e4aaaa0c423904eb747">
              <SHORT-NAME>RLDoorOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b85876288c83526ae4add1f493b9efc">
              <SHORT-NAME>RLObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac23b174ff4a3dcdaeb2533f11306a02">
              <SHORT-NAME>RLRdrEmgcLineChngWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLRdrEmgcLineChngWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95dacf6894a03b14883ed90990db2a02">
              <SHORT-NAME>RLSInitnFltPrst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSInitnFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="89c3e0faa8fa32db9f412d5515081706">
              <SHORT-NAME>RLSObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="829e09d3ef823c64848c342adff7dcb4">
              <SHORT-NAME>RLSSPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39ad64f3085f38bf83aa249c9ee76b7d">
              <SHORT-NAME>RLSUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="834f17703106391d98ef231eac02cdf2">
              <SHORT-NAME>RLSideLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSideLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="faed9b1b6db638bf9e944e700df3b704">
              <SHORT-NAME>RLSideObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32d5274cab24358fb9b64f1481dd4bfa">
              <SHORT-NAME>RLSuperLckSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd813b4dcccd30fc9f5a2b73aacdfc54">
              <SHORT-NAME>RLTirePrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1011a5df9abc3a588450b34920ba9588">
              <SHORT-NAME>RLTirePrsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="76d899d8aa8335b3827972e5a71a0d85">
              <SHORT-NAME>RLTireSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6aa4b2968cfb3332bcad4167c52b91a7">
              <SHORT-NAME>RLTireTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="71a5a4fa53fa34e1b487609c8a9ce015">
              <SHORT-NAME>RLTireTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f3be583470c30f7bd30a79adb3eb07f">
              <SHORT-NAME>RLUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5812a6ccb38638d6a5cbd7a2d1843af8">
              <SHORT-NAME>RMLUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ef2d021aa5a3159b6d791f8710afd3a">
              <SHORT-NAME>RMRUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fa7cbd479d05323a82abd69e9626c865">
              <SHORT-NAME>RMainBeamLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMainBeamLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88fede8667513063acf7592c0318f6e7">
              <SHORT-NAME>RMainBeamLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMainBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="043565060a13380cb00e8df882c3d205">
              <SHORT-NAME>RNonDrvnWhlRotlDircn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fcf9755737b130178df9a96a95341858">
              <SHORT-NAME>RNonDrvnWhlRotlDircnSdslSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDircnSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="258218a799d83e318737a28d02cb9b6b">
              <SHORT-NAME>RNonDrvnWhlRotlDistPC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistPC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca9fb8a8194d337dad52d14b04adbd13">
              <SHORT-NAME>RNonDrvnWhlRotlDistT</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistT</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1d1e051766d3155b9577e7b30a71101">
              <SHORT-NAME>RNonDrvnWhlRotlDistTRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistTRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="403cdd94598f31af90717aca106bb613">
              <SHORT-NAME>RNonDrvnWhlRotlDistV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9cf4a472af613ccc9e993113fe296cba">
              <SHORT-NAME>RNonDrvnWhlRotlRstOcd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlRstOcd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b567b60b0bf33d697476f338a9bf26a">
              <SHORT-NAME>RNonDrvnWhlRotlSeqNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlSeqNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21522e99fee237b698e69d4e64d27024">
              <SHORT-NAME>ROtsdMirFoldSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirFoldSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1deac89d58c93526910e2be448e6cfd3">
              <SHORT-NAME>ROtsdMirHoztSwActReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirHoztSwActReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="10d6aac27ea8380cab14e0d72413b166">
              <SHORT-NAME>ROtsdMirVertSwActReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirVertSwActReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d94a3c86ec4a3f22becba57c9ba07f30">
              <SHORT-NAME>RPShockDistL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RPShockDistL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c794b0ba2943ca5916487f941ea1959">
              <SHORT-NAME>RPShockDistR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RPShockDistR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="980021e742f8374ca166c71adb3dbcac">
              <SHORT-NAME>RRCTAWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRCTAWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1d8106c3db23d0f8e3b6a70895302c1">
              <SHORT-NAME>RRDircnLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65fa174eb41a3b578495235563fd1073">
              <SHORT-NAME>RRDircnLghtFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="daa36a9499c034579419e35f24e0bdee">
              <SHORT-NAME>RRDircnLghtFltsts_HW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtFltsts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9be6cb917f643bd2b9d1c351b7f918f0">
              <SHORT-NAME>RRDircnLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="911bab56b6d53286bdc6fc93770535b4">
              <SHORT-NAME>RRDircnLghtSts_HW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64eceb4551bf37f691f36d9d7deabeea">
              <SHORT-NAME>RRDoorOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2adf16c3bcb73236855c3bf8822f3071">
              <SHORT-NAME>RRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f0dad54ab673d4489bc81a231e8f92e">
              <SHORT-NAME>RRRdrEmgcLineChngWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRRdrEmgcLineChngWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de51fc0d0e8532698bfee31105d928b0">
              <SHORT-NAME>RRSObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b84af54b21023a8b82370f8e6ecbc20e">
              <SHORT-NAME>RRSUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a13ae8e3cc993efcb41d91e244255310">
              <SHORT-NAME>RRSideLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSideLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e3ea45a7fc13b1f8c94371dec373ad9">
              <SHORT-NAME>RRSideObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d47a7d27dfb3d648aa3b41eba8c4ddb">
              <SHORT-NAME>RRSuperLckSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="42dd15c5af2738729d13a9545f8a6761">
              <SHORT-NAME>RRTirePrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5cc34fbad0673e19ac46585d55fec309">
              <SHORT-NAME>RRTirePrsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b869597fca33e98a51ebb7d48433e05">
              <SHORT-NAME>RRTireSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79ee95f31de8345b9f15e1f68ef7b36a">
              <SHORT-NAME>RRTireTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="30057f437eff33a8aa559e06408546c3">
              <SHORT-NAME>RRTireTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="527a9f3750e6336eba6d98d823e05e58">
              <SHORT-NAME>RRUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f72e0991d7833f4297441ca33cb810b1">
              <SHORT-NAME>RRWinIninSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinIninSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="236431e51f173470a9a7aeec585ec561">
              <SHORT-NAME>RRWinLclSwtFlt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinLclSwtFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="111e663788e037cca3e6de7dd77e3912">
              <SHORT-NAME>RRWinLclSwtSts</SHORT-NAME>
