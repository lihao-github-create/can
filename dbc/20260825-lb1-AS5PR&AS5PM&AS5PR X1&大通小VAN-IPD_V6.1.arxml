                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6930ba4391c23c7a86c57bfeb471ba71">
                  <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f25d7f684af3365f84cb538772d579b1">
                  <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONTMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4a06b419e15332ef8db1f54bbbb8fc21">
                  <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4d4bd899e72a312d8b8b1eacadfaa37d">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSlntPtrlEnbSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ca1381238cfa34fd893c21aff000df7a">
                  <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f922ad616c732059cf14bc3405234b7">
                  <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntDistNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7ad58f50bfbc3b99991516e628688694">
                  <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntTypNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="935b544d3b313facb7dcb6de608349f0">
                  <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2b00eddcdd4d38799c4a3e814a911f1e">
                  <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8ef9ac91d4d93ff597946f523fe620ab">
                  <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8fa5a9cb104a3aefacf63038dcc09173">
                  <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8e69e83196cd3863a18247814341653e">
                  <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="20aeacc36e1a3653a5864d0ee115bbe3">
                  <SHORT-NAME>NOPSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c0409cc6b68733b38ae14cf6553f4498">
                  <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssQuit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d9332ac2ba13df4ba2a03b27dd6a6e4">
                  <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e523fbf3b2e53745b026d885085ca208">
                  <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c9e68b0032e63645aff98b9eab0c084e">
                  <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCndSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f5cfe489bfc39ff9c981b939ec9d2a1">
                  <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCrntRoadTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ca1f8c746ffc3b8ead2425ad41da2944">
                  <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCtryCode_ISO</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="560b97294215334193bbd9645775258d">
                  <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavDistFromFrtEleccEye</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5d429e7eaa053b429324ab99da4263a1">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavItvalSpdDetnDistRetDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b4e23343134b379696e6e4d7aecf102a">
                  <SHORT-NAME>NavNewIconDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNewIconDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1f34acb331843d3ebc419e8e64a1c44b">
                  <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNextRampOffset</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="863ba4131d7f3620b88fb34f77bebe40">
                  <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e89659b359d4345c8f3762195701d12c">
                  <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7bd43fd5938632fdb55eaca50977d62e">
                  <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a143107b80483fd19ac12db786358557">
                  <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValUnit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="79f783dde64330c68cf4ffe622e607fa">
                  <SHORT-NAME>NavSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6c5fef23c7443313ac0700051f05ee46">
                  <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="08e9fa673c1a35d89518974293ae636e">
                  <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NorthVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="764494e59a3739e28fa0f801f6e1b2fa">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2eab6f56e8dc3a72a5e5e84b359079df">
                  <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2fe86a9ef4c03dd690e574336f5c902d">
                  <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="496558cb0503311f809dfd273e9b9a17">
                  <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eb286443ddf73b9daedded86b9cb5283">
                  <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f160ab92214304e98186be103b759a0">
                  <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OnBdChrgrOptAltPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cf92104d8f8f3d9e943ed62a9f86fae6">
                  <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9ced32a52a3c34be9fcc76f224eca7b6">
                  <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValMsk</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f5f98d7768e537d5aa6a6b2ad007853e">
                  <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a842389d334935989a9078d472ee9fc5">
                  <SHORT-NAME>PEBSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="826dce9dee783c6a929b1e4a39f41f06">
                  <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEU_10ms_Group25</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2f601049208d3aeb9bd4c032ecb893fc">
                  <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6477546bbadc3cc7b61cef7f856951c4">
                  <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5592444f6b633a4db5863808031f33dd">
                  <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="099cf306b0d33719b7c9328e5ca94f57">
                  <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_PTAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ac570d535de73914b91b95e60df52d44">
                  <SHORT-NAME>ParkngDirSw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3e7bb00dd0d63844a172dfe5d7e12b35">
                  <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PositionAttitudeStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="229e08d47866309280ddae777e451a74">
                  <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrDMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="58aa198140b53e4eb9d376da9f5a491d">
                  <SHORT-NAME>PwrReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="94745f66c3c933a7bfc9e2dc225079e9">
                  <SHORT-NAME>RACtlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RACtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5e66f14bd4b835fd8f1eb9e2e7ef5c45">
                  <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="93532ddc225c36718602c6c17c724adb">
                  <SHORT-NAME>RCWSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f732a0e277dc3adaa13cfd44b1c9eaaa">
                  <SHORT-NAME>RDASwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RDASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fd80dffb370037308b6fe7cc9a3f0af5">
                  <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="40d9d6386570340ba3e9d5e6c53ee78b">
                  <SHORT-NAME>RFSDA_20ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFSDA_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fc8bd0b5a8a83c28b6ebc2fb51e76ea4">
                  <SHORT-NAME>RHRDA_50ms_Group04</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHRDA_50ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f644e95283b5343a8fd6185fd5d9180c">
                  <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="48eb025a6616351ebb9d6db054322252">
                  <SHORT-NAME>RHZCU_100ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0cb4e9734f433b05845ad62b8c7fbb41">
                  <SHORT-NAME>RHZCU_50ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="292b00cfdf983a178b90c582ed62c329">
                  <SHORT-NAME>RHZCU_50ms_Group27</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group27</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a2cb4b1f49233e42aa18eff7ec9fbcee">
                  <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUeFs1Sts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fce03b263b3b32d0a782e478cd7a2554">
                  <SHORT-NAME>RLTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0ef0a334fbe0390b8d3024fd40a2d826">
                  <SHORT-NAME>RLTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="23e3b92cace838b0829f5c2d0aae0341">
                  <SHORT-NAME>RLTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5daecddcc87f3792b8efa5719a3040ad">
                  <SHORT-NAME>RLTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="976674c187f93a7fa92b8b1fd8044471">
                  <SHORT-NAME>RLTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8757ab52f3f83736912c1d8a9e1e1cb2">
                  <SHORT-NAME>RRTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="461c22bf63ca33fcb8540bc45870e399">
                  <SHORT-NAME>RRTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="71e6cc810ae4323588b9889ccb3eba16">
                  <SHORT-NAME>RRTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="094521632f363b22955291df6e399549">
                  <SHORT-NAME>RRTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="369a0d4dbea63e4caebeed9254f7e518">
                  <SHORT-NAME>RRTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d537089084b357f837f141378008dce">
                  <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnDiagSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="be33f4e5770330c3b754d27e71a25d8e">
                  <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f84fb723de6030d398463de1ee42c3ac">
                  <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="89bb463667933c60bc5c58836bcb591c">
                  <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bfa02efb972d3fc5b9d32bc7e7ae8b65">
                  <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="21b37d93bd66386ba99d32c5d37fa7c1">
                  <SHORT-NAME>RZCU_10ms_Group22</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group22</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d6475b4dd94d35fe84dea80fdc167a4d">
                  <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8cc64e661f663f40a615cd743a79bedf">
                  <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="846dca70148e36979dccd4e144f7af70">
                  <SHORT-NAME>RZCU_10ms_Group90</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group90</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cbded8b4519c3095b8ba77351ed30dc0">
                  <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_20ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="98ee9b23aa4a36a4adde8f6a201ac7a6">
                  <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_50ms_Group37</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2b9db974e95b3db0820c858c5ecf017e">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_BKBCANFDAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5d249ca8118b369190f7bba45488cd85">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_ZONE_10ms_Group64</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b7a7645806213ae9824928f8a4332983">
                  <SHORT-NAME>ResetCnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ResetCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8e0aa22e3b4c3ccaac7298487a25c3b7">
                  <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Rolloff2Min_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f94d04a325893eb1a15920105834653c">
                  <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RolloffHld_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="041e6515dea23803afebfc77160e3f5c">
                  <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="91ea6314e0ac334aaf8ec918e11d50a5">
                  <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RstrFctryDeftsReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="da2775ae33bf342ca039ef2f4be9b131">
                  <SHORT-NAME>SDMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9bdca2f095c23e3d8c9ab7264061157f">
                  <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b777a8160b3e39599806d4fa5a34c7b1">
                  <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e528680561f933b285d7d0a6582bc1a5">
                  <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3bbae0890cae3f9f87837628c7ecda99">
                  <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="90d84d88136b303b8b1cd9b0367a7b63">
                  <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bda9ec8baf903b3097a5ff0bd2779249">
                  <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLowPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="03af9201819e3ca09e5f29551c79048a">
                  <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLvl_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af6abde3cdcb3cc39370a76115e11f6a">
                  <SHORT-NAME>SOCMd_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5fec6beeeaa3175a26fced289770e85">
                  <SHORT-NAME>SatAz1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7ca3573f480c33ac8443f6db9e8e3e81">
                  <SHORT-NAME>SatAz10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="875800467ca634c8a25dedce01c1daef">
                  <SHORT-NAME>SatAz11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e24c0207a0c831b39d0e93b1eb0f8582">
                  <SHORT-NAME>SatAz12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f6e31723f1c43a6d80810f63fc20ad06">
                  <SHORT-NAME>SatAz13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5483e20dec6d3f11ba181c0369ad1c99">
                  <SHORT-NAME>SatAz14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="abec20ac8e583938807c995f487b8095">
                  <SHORT-NAME>SatAz15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="00c777dd4b283d6f90959edaee36c2e7">
                  <SHORT-NAME>SatAz16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="552e0a8bed583a52b8c26714d3bf0762">
                  <SHORT-NAME>SatAz17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b5a745fed6163874bbc6a4709b938db4">
                  <SHORT-NAME>SatAz18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7643ebdc44903178877a394109292134">
                  <SHORT-NAME>SatAz19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="87ae0a24f3af394b864aa0856141bade">
                  <SHORT-NAME>SatAz2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3f5a034c01043e8b9e9d4aba39be31d5">
                  <SHORT-NAME>SatAz20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e306df3dc4bb360382669ba3ec7712bf">
                  <SHORT-NAME>SatAz3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="35bbfce53dd4343c8b2878c06255e9f0">
                  <SHORT-NAME>SatAz4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0f9049a51f983466ba6be55ef533b784">
                  <SHORT-NAME>SatAz5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e6e4da2ba7dc3f25a650e54c47722071">
                  <SHORT-NAME>SatAz6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e3841b4c7c773bddaaeeaf3b92872a43">
                  <SHORT-NAME>SatAz7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4447639057aa38b9833d3a81ffe2f5e4">
                  <SHORT-NAME>SatAz8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fa625698116c3225836518f16ec89858">
                  <SHORT-NAME>SatAz9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cd67a36b7ca23fab9751373791f29702">
                  <SHORT-NAME>SatCNO1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="75b337e161633a1fa2314ce69441d499">
                  <SHORT-NAME>SatCNO10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="89c1b90f963636bb888936132f3912ff">
                  <SHORT-NAME>SatCNO11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e0b8e0db9da73f97b3d840e722f5da86">
                  <SHORT-NAME>SatCNO12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ad5952a6c80b34d4b2eb13aa11c47dc6">
                  <SHORT-NAME>SatCNO13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="311168b732223a259f5be7875dcb55d8">
                  <SHORT-NAME>SatCNO14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f78b01edfd553af99b60b88b33ca2bb0">
                  <SHORT-NAME>SatCNO15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4bddcbde60dd37ac8dfed875717d9b3b">
                  <SHORT-NAME>SatCNO16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="29875a988c7e3fc3887f8a770078fc38">
                  <SHORT-NAME>SatCNO17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8a961cae25f4347887f8768f25eeaf87">
                  <SHORT-NAME>SatCNO18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="64d2926aedb53963bc63aabf7e86c645">
                  <SHORT-NAME>SatCNO19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60fae4ee961e31b2becb9407fc63fb5e">
                  <SHORT-NAME>SatCNO2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="111ccf8a405f348abe3dc2808da37539">
                  <SHORT-NAME>SatCNO20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1a34d31266c537a0b06230905adb7d6e">
                  <SHORT-NAME>SatCNO3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f4dc568b2af33a3eba1e9a5bc682f1e3">
                  <SHORT-NAME>SatCNO4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="82b64065618b3cd5b426a2618f84fdeb">
                  <SHORT-NAME>SatCNO5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="dcbac458894b3dff9c318c5b2030838c">
                  <SHORT-NAME>SatCNO6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2bbd0608ef1f3728a99f8e80bd49db02">
                  <SHORT-NAME>SatCNO7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d40a4e9cfad13fbf8594f2dca15428c7">
                  <SHORT-NAME>SatCNO8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="79d743ef902e3057b9aedd24e82f248e">
                  <SHORT-NAME>SatCNO9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d2feaf307df53ac2aead3f33a4e825e4">
                  <SHORT-NAME>SatElv1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="56ae04a4131435069bc050634e1b6a60">
                  <SHORT-NAME>SatElv10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1ce42ee7c6563a52844abe03e23c0cb7">
                  <SHORT-NAME>SatElv11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="10490bb7a3183eeaa991872f9ecdb1bf">
                  <SHORT-NAME>SatElv12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="59f51c07b68e35e3925f519cb51b35dd">
                  <SHORT-NAME>SatElv13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c898a0548008364cbdc97f15aaac9f8b">
                  <SHORT-NAME>SatElv14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d3bfec60dd1b37cfbf2b4ed43fcd941f">
                  <SHORT-NAME>SatElv15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c7e3e22f3d013791af0a376cd955308b">
                  <SHORT-NAME>SatElv16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7abccff3a6fa32f38635977cfaea669e">
                  <SHORT-NAME>SatElv17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a270ab8c845b39acb3e437e2faa7b6dd">
                  <SHORT-NAME>SatElv18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="788b9acb466f39a5ab745290eb443b31">
                  <SHORT-NAME>SatElv19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="910ee1a96cf730ccadd535eda5929d49">
                  <SHORT-NAME>SatElv2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c5e4aa693465344db65852d273ecd8b7">
                  <SHORT-NAME>SatElv20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="66a2cad1481430dc9a55dba1407c0784">
                  <SHORT-NAME>SatElv3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="85c5d04772b43bbbaf3279202b95ca61">
                  <SHORT-NAME>SatElv4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="440f01e21af83b0d821a89cf5a6e29cf">
                  <SHORT-NAME>SatElv5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="688087e9acbe383e91f67b65f1656977">
                  <SHORT-NAME>SatElv6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e2302875d6263c6c895a0b42f6ec2f4f">
                  <SHORT-NAME>SatElv7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8a9b0838dfcd3abb9378a3fc63648ae3">
                  <SHORT-NAME>SatElv8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8011681c21d839198867768a0cdfa7fa">
                  <SHORT-NAME>SatElv9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8206e0679283335ab97968704b597ee9">
                  <SHORT-NAME>SatID1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cf4ef23903b23e4cb6b218c059b6a249">
                  <SHORT-NAME>SatID10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="255e663c865934b6a86850d476792d1f">
                  <SHORT-NAME>SatID11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f53abe9fb1ce379dbcc480e3b3981818">
                  <SHORT-NAME>SatID12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="377df04729213a2dac0bc4049cce490e">
                  <SHORT-NAME>SatID13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5dd1e73b91d93732a994b3f4d9e24f11">
                  <SHORT-NAME>SatID14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e08031f9b8ac30c88eb260f159533e34">
                  <SHORT-NAME>SatID15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="315641954f4730a3a70d68ff1ee45213">
                  <SHORT-NAME>SatID16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="778a56b407e933ac9ca7970932efb37d">
                  <SHORT-NAME>SatID17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9367b14cf46c33319ff5999865b4c989">
                  <SHORT-NAME>SatID18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4c9099e3f3323d4a8cec675a50e74bfc">
                  <SHORT-NAME>SatID19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="08f4dab4e93233f1bfc33978c121273b">
                  <SHORT-NAME>SatID2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7d687822f01f323fa74501d816bffb9c">
                  <SHORT-NAME>SatID20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2bcfc267dc4431f2bf710495647a1720">
                  <SHORT-NAME>SatID3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8e0fe7e63f1f30f79b2c7f24f3b3f9f1">
                  <SHORT-NAME>SatID4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8fb39391bd8d33d8b472ef2e4f3c1c74">
                  <SHORT-NAME>SatID5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ad582f67d25e374b8c596727e28fb6dc">
                  <SHORT-NAME>SatID6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="21bc1f8434853cc687071e71c59a20cf">
                  <SHORT-NAME>SatID7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="df0f860d194636bd809abd997200c12c">
                  <SHORT-NAME>SatID8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="97da708c43d7304bb5226263c05dd9eb">
                  <SHORT-NAME>SatID9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2d86f676edd03509b493b54176bfbcab">
                  <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInAttitudeRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="29c0b12f31af33518606494e02b71f08">
                  <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInPositionRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1bd4a36ec88c339480ce0d67f3fd524c">
                  <SHORT-NAME>SatNum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="06ed1a580d803b2599da5f7d1aff8a3e">
                  <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SeatOccptnNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e2e6f5c7e7933d2daf6eba37f7e91d7f">
                  <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ShftSeqStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e2c6e38fc5e23714bc83cefb47dc30d6">
                  <SHORT-NAME>SideLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SideLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3167f00899d4323e8b8e633c442e09f1">
                  <SHORT-NAME>SpdLmtNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d5efceeb3ff33e28b3fa416cff9ddb9e">
                  <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a06c9dd5fab136e0886c6c659310e28c">
                  <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="010a275d7ec63ac696033426dc7d9ead">
                  <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="066e51b4f0803ee2ad423fd3e710fab4">
                  <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtPathRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b6d489d6f1ee30e095e8ef4c975408d7">
                  <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="aa23300861bd36568e803dcc9745cf32">
                  <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/StrtTypAvail_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="99fdb98a859b3d5fbcd30871cddbfb98">
                  <SHORT-NAME>SvGroup</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SvGroup</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ed609c56832a3f3daa1e56e52250b64e">
                  <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASSAMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cb00be6ce666396ab454ba97d0457534">
                  <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASTMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f44bb16e61ed3112b8da65e0db74e2c5">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_020ms_PDU18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6e4225ecec81341cb08213b98efbfc60">
                  <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="48fc00fd2c17390cba86dc752c5e9b71">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_PDU20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b6877ebd24f33499bb8785c738cda0a9">
                  <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_PTCAN_FrP05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="56c4b297ce413f6c903b24376ff5afa8">
                  <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvSAMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3fba38187ef6398892393120d218a5ac">
                  <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvTMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2e5371d3d48030078323acd43c0df2e0">
                  <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUOpSt_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="89fe9db4f179326b998cb779c45f697c">
                  <SHORT-NAME>TDMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2d3662c08bb930d9b2a69c3f7154f476">
                  <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDM_200ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b1573884657734cdb4e75c762e1b2ac5">
                  <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fee6f6db4d8e3aa182075e00a8c680e0">
                  <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSBtmNosRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="afc439a36dd835459ad610bbb76cedba">
                  <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b903e0c64c1b37d4a369936712871910">
                  <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrIDLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="138ec614ca6c3885bd087f4455b9dfd5">
                  <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3eb832fdcac1310fbf13535b2cde6042">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="19b10fa84c1a3f68869198fadc854021">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtrLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="04ae05b082c03392af84b015af3fe77d">
                  <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSWntrMdA</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="de3ad7990fd53e4c9df90b50d4aa66b6">
                  <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TQRTMTqReq_N</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2a61efb92b173fc8be24eacc4cb1e35c">
                  <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="97a2aa51cf713c12af1f0c080b5c03a5">
                  <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCTqDmdSTC_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="21cd56d92e7b3dd390a7bd360f7b183c">
                  <SHORT-NAME>TSRSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f02d774f4fa33597abc36eea9517d86d">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMMaxTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8566c1b2834035619446bcc38e99d8ce">
                  <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="507cd41761573ca1bc4606aad70947a6">
                  <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TemSnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b55ba376a35a3a45a674cbf2e56e7918">
                  <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TqCtrlStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="047e731b8cbe3c80a49bf8058b9eb342">
                  <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnKeyBtnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="20ba87ea5e4535bb95edacda2b42f106">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyFindCarSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8414bf3e29a53980b926d3249fc9a378">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3ee0abafe0e0318ba828580e0355926c">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLdspcSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b54227049b3d36049c3dbaebbbff1ae6">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyUnlckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8b54ac0bb7903a9ea0768a790eb930c7">
                  <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcForbidDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3dab4c654a793cb6aa551d8ef28653c8">
                  <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcInfoSignDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6ab0b7a037003ebca43b79872953696e">
                  <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcJamRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c7d709821443380a8f57192c62d9d625">
                  <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1b1b8dd52c7c3ea3817a92c4fa853634">
                  <SHORT-NAME>TripCnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e8d6dae0b94f35f5942ae83787ef5078">
                  <SHORT-NAME>TripCntResetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCntResetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9821053f8002350bb97abeca3a469c20">
                  <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VDCSlipCtrlSts_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c9d04ea274f83b6195597522a8107e4d">
                  <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshDay</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e9248c3a18fd3bf1af73891823ffa65c">
                  <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshHr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c2916e35be2f319eb1c7c88a76047b0c">
                  <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMins</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4ecd2372897635efb6630d1bae746dbc">
                  <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMth</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9ca6ad538c0c31eea0b94b27c11436f9">
                  <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshSec</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c7471d92d246392aa2a438055a5c3d2a">
                  <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshYear</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="022ced5287f13ca2a397faa23ddda0b4">
                  <SHORT-NAME>Veldownsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veldownsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7a6d0e3f00e43117b31a566858fa8b4a">
                  <SHORT-NAME>Veleastsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veleastsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8138249a964d3354a16dd6f97b73fe7d">
                  <SHORT-NAME>Velnorthsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Velnorthsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eac520a6d5863d3c9780b4f4fe467193">
                  <SHORT-NAME>WhlRghRoad</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0e5e399a5e0e3a9a96b423b6e46ef804">
                  <SHORT-NAME>WhlRghRoadV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoadV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
              </PORTS>
              <COMPONENTS>
                <SW-COMPONENT-PROTOTYPE UUID="Na505a3f19f25843c4b1dad7XNa505a3f19f25843c4b1dad600">
                  <SHORT-NAME>MComposition</SHORT-NAME>
                  <TYPE-TREF DEST="COMPOSITION-SW-COMPONENT-TYPE">/SoftwareTypes/ComponentTypes/MComposition</TYPE-TREF>
                </SW-COMPONENT-PROTOTYPE>
              </COMPONENTS>
              <CONNECTORS>
                <DELEGATION-SW-CONNECTOR UUID="312938661b14364581bbbd9852e58bdf">
                  <SHORT-NAME>ACCConfmSwReq_MComposition_ACCConfmSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCConfmSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCConfmSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2af893f193f5309489088b11ff236f80">
                  <SHORT-NAME>ACCConfmSw_MComposition_ACCConfmSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCConfmSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCConfmSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f20a295c20a03ff7a118e15a3478ca8c">
                  <SHORT-NAME>ACCCurveSpdSwReq_MComposition_ACCCurveSpdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCCurveSpdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCCurveSpdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5d450ae652e38f1b389b7c082fad83f">
                  <SHORT-NAME>ACCCurveSpdSw_MComposition_ACCCurveSpdSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCCurveSpdSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCCurveSpdSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b87f707ebb513db7a058186c40996b88">
                  <SHORT-NAME>ACCDetObj1ExistPrblty_MComposition_ACCDetObj1ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8143fe69dd273a84a09a6c25acf382b2">
                  <SHORT-NAME>ACCDetObj1Id_MComposition_ACCDetObj1Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7cba59ded87b34b08b645bc854cf19e1">
                  <SHORT-NAME>ACCDetObj1LatRltvDist_MComposition_ACCDetObj1LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d7df7c0ab283921b7da1873d857faf0">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist_MComposition_ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a7b2b91073683de388038cd0b5bb03b4">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd_MComposition_ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8d57356d67983feb844cb92971447dbb">
                  <SHORT-NAME>ACCDetObj1Risk_MComposition_ACCDetObj1Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="04f9f2d95ecb3de282dd5ea393d82d08">
                  <SHORT-NAME>ACCDetObj1SyncCtr_MComposition_ACCDetObj1SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7782e4aa6feb344280f025ca22b8d849">
                  <SHORT-NAME>ACCDetObj1Typ_MComposition_ACCDetObj1Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a287c8255f53d869d141446093da5ff">
                  <SHORT-NAME>ACCDetObj2ExistPrblty_MComposition_ACCDetObj2ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d26ab3af02b3769a0b156532fd4b641">
                  <SHORT-NAME>ACCDetObj2Id_MComposition_ACCDetObj2Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fe8c39b90a7c325696dfbc258df66248">
                  <SHORT-NAME>ACCDetObj2LatRltvDist_MComposition_ACCDetObj2LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3244000880e331c493995f483d80dd10">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist_MComposition_ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="47c151f2afbf330f8ad9b887071a447d">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd_MComposition_ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4732d433d70f367582ded9aeb56b75ea">
                  <SHORT-NAME>ACCDetObj2Risk_MComposition_ACCDetObj2Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8de43278853a3a75b3a83a6c9287cb55">
                  <SHORT-NAME>ACCDetObj2SyncCtr_MComposition_ACCDetObj2SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="30372933d0b236dc88431dd30851b60d">
                  <SHORT-NAME>ACCDetObj2Typ_MComposition_ACCDetObj2Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="19701770e3c833bf98bb748bc53e0071">
                  <SHORT-NAME>ACCDetObj3ExistPrblty_MComposition_ACCDetObj3ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b86a5bb00d8a38b18fbeed5701695808">
                  <SHORT-NAME>ACCDetObj3Id_MComposition_ACCDetObj3Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c2366fe403039b082ec65932c15c745">
                  <SHORT-NAME>ACCDetObj3LatRltvDist_MComposition_ACCDetObj3LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f21fa6119dad3419877e504581c6fba0">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist_MComposition_ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3d621e8f2a9c3ffbabe9fd133d4f84e9">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd_MComposition_ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d43df4d96acd3fe6a2032abe39c83135">
                  <SHORT-NAME>ACCDetObj3Risk_MComposition_ACCDetObj3Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f383f7b5b4403bbfa97b728bf9dd83e0">
                  <SHORT-NAME>ACCDetObj3SyncCtr_MComposition_ACCDetObj3SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="354f334d70593552bccc3d2c41b20656">
                  <SHORT-NAME>ACCDetObj3Typ_MComposition_ACCDetObj3Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c00f859e4e963049b288e862e023998a">
                  <SHORT-NAME>ACCDetObjExistPrblty_MComposition_ACCDetObjExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="afc43004091831fbb9eefde4b8b4dae7">
                  <SHORT-NAME>ACCDetObjHdngAng_MComposition_ACCDetObjHdngAng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjHdngAng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjHdngAng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd1aa79cccc23bbc9b3664b38af38b90">
                  <SHORT-NAME>ACCDetObjId_MComposition_ACCDetObjId</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjId</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjId</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eacfb71278123f38ba68a76ce2c9a208">
                  <SHORT-NAME>ACCDetObjLatRltvDist_MComposition_ACCDetObjLatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="13a9d01b2f84375db3ba53eda706215e">
                  <SHORT-NAME>ACCDetObjLongtRltvDist_MComposition_ACCDetObjLongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="054ca16f168b3f1b903035c2d8ae79d5">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd_MComposition_ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="231b51ce680d34ebb5c5304087dfdbce">
                  <SHORT-NAME>ACCDetObjRisk_MComposition_ACCDetObjRisk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjRisk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjRisk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="06400d3d91cd3e69baea8196d25bdf38">
                  <SHORT-NAME>ACCDetObjSyncCtr_MComposition_ACCDetObjSyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjSyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjSyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87db26418a79398fb1640d5b6cabd5c4">
                  <SHORT-NAME>ACCDetObjTyp_MComposition_ACCDetObjTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjTyp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f10625e423573341bd91fbcc6fc0a085">
                  <SHORT-NAME>ACCDrvrTkovReq_MComposition_ACCDrvrTkovReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDrvrTkovReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDrvrTkovReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f2becc74c6f937b8a8377debbde8c0c9">
                  <SHORT-NAME>ACCObjDet_MComposition_ACCObjDet</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCObjDet</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCObjDet</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5875702b2bd83374b6e43d29b1f65ee9">
                  <SHORT-NAME>ACCSpdLimtSwReq_MComposition_ACCSpdLimtSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCSpdLimtSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCSpdLimtSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="44e764c7f857304d87bded438ccea489">
                  <SHORT-NAME>ACCSpdLimtSw_MComposition_ACCSpdLimtSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCSpdLimtSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCSpdLimtSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="529b6b40acb4327992a90e9481a38d6c">
                  <SHORT-NAME>ACCStsForEdr_MComposition_ACCStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4fa976770a283f8dac17f38dc94db460">
                  <SHORT-NAME>ACCStsSwReq_MComposition_ACCStsSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1a0c6f4de16f323693e38537233b1049">
                  <SHORT-NAME>ACCStsSw_MComposition_ACCStsSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="510e80476fee3cf0a865a64020f5a7b0">
                  <SHORT-NAME>ACCTJAMdSwReq_MComposition_ACCTJAMdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCTJAMdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCTJAMdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3fbf5e0dc6b33db8b3d46ce7f748b528">
                  <SHORT-NAME>ACSFCatgrAStsForEdr_MComposition_ACSFCatgrAStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrAStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrAStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a7a675f22621310785c15c0005c65b4f">
                  <SHORT-NAME>ACSFCatgrB1StsForEdr_MComposition_ACSFCatgrB1StsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrB1StsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrB1StsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="04165f54dff13790a2cac601b636f733">
                  <SHORT-NAME>ACSFCatgrB2StsForEdr_MComposition_ACSFCatgrB2StsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrB2StsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrB2StsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0288ae6dd9673f66a512c34a4cd211f7">
                  <SHORT-NAME>ACSFCatgrCStsForEdr_MComposition_ACSFCatgrCStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrCStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrCStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aaba8998b8073edb9908f9ba146a3cfa">
                  <SHORT-NAME>ACSFCatgrDStsForEdr_MComposition_ACSFCatgrDStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrDStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrDStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0505d3cef7dc3cbbac99ee94829b26a7">
                  <SHORT-NAME>ACSFCatgrEStsForEdr_MComposition_ACSFCatgrEStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrEStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrEStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c55ca9fe494e37329a66c13f6b3ec4eb">
                  <SHORT-NAME>ADAudioSWReq_MComposition_ADAudioSWReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADAudioSWReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADAudioSWReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce62fe782ad53ae3832cd86f7dc7905e">
                  <SHORT-NAME>ADAudioSWSts_MComposition_ADAudioSWSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADAudioSWSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADAudioSWSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84458be6a50135ceb307a1a5932c4840">
                  <SHORT-NAME>ADS_ISAMsgReq_MComposition_ADS_ISAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce19a0376a753fef808e488a22ad7d64">
                  <SHORT-NAME>ADS_ISASysFltSts_MComposition_ADS_ISASysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISASysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISASysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d55b861b882e3eeea86a05b6cd98e9fb">
                  <SHORT-NAME>ADS_ISASysSts_MComposition_ADS_ISASysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISASysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISASysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57112ffaaa2e3beda6ddef87dc1939a1">
                  <SHORT-NAME>AEBDspCmd_MComposition_AEBDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fd1c7dce68253a87a9686f3c5b78404b">
                  <SHORT-NAME>AEBMsgReq_MComposition_AEBMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6111b20a568d3cd997bbf259ccc84837">
                  <SHORT-NAME>AEBStsForEdr_MComposition_AEBStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e4a4f37052d3dcd87d39cdb1862eb6e">
                  <SHORT-NAME>AEBSwReq_MComposition_AEBSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb036db5a1143b1f9bfef0909603f2f7">
                  <SHORT-NAME>AIParkngDsp_MComposition_AIParkngDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3aaea8c1b6a93a01bcb84c6f923cdd70">
                  <SHORT-NAME>AIParkngEPAMdsts_MComposition_AIParkngEPAMdsts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngEPAMdsts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngEPAMdsts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="74a1bcf7f12c36da99009000efb02caf">
                  <SHORT-NAME>AIParkngEPAMdsw_MComposition_AIParkngEPAMdsw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngEPAMdsw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngEPAMdsw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="309e1d3898903d25aece648cea9065db">
                  <SHORT-NAME>AIParkngReqICB_MComposition_AIParkngReqICB</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReqICB</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReqICB</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f983c59976c3f86b04c0b90ca86150e">
                  <SHORT-NAME>AIParkngReq_MComposition_AIParkngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ba64ab55208a3df2bd8cb1bdeeff20c9">
                  <SHORT-NAME>AIParkngReq_ZXD_MComposition_AIParkngReq_ZXD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReq_ZXD</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReq_ZXD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="51cc2a853bbd3e5e8944f011735e436b">
                  <SHORT-NAME>AIParkngRespICB_MComposition_AIParkngRespICB</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngRespICB</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngRespICB</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e9fcbebc922b3270a68eab494247f2d3">
                  <SHORT-NAME>AIParkngSSPLotSwSts_MComposition_AIParkngSSPLotSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSSPLotSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSSPLotSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fb08420e20d3356dbeb306af5ae8ca40">
                  <SHORT-NAME>AIParkngSSPLotSw_MComposition_AIParkngSSPLotSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSSPLotSw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSSPLotSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c22f9bfda4ab3150ab792837500ff279">
                  <SHORT-NAME>AIParkngSpcID_MComposition_AIParkngSpcID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSpcID</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSpcID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f152c14a3c583191bafe1e12fa7dba29">
                  <SHORT-NAME>AIParkngSpdsw_MComposition_AIParkngSpdsw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSpdsw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSpdsw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="caca116fe6bc3a9d85ddb75a6f37ffff">
                  <SHORT-NAME>AIParkngSts_MComposition_AIParkngSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e9cfc48a06c63cb8bf9da4a565bdef91">
                  <SHORT-NAME>AIPilotIntervQuit_MComposition_AIPilotIntervQuit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIPilotIntervQuit</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIPilotIntervQuit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="981c588245773567970b007bb5ec2d14">
                  <SHORT-NAME>APAOneKeyParkSwReq_MComposition_APAOneKeyParkSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAOneKeyParkSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAOneKeyParkSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7476699d575438008a79e90d102e27c2">
                  <SHORT-NAME>APAParkInOffsetTypeReq_MComposition_APAParkInOffsetTypeReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAParkInOffsetTypeReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAParkInOffsetTypeReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="52718a12147d3f9a8175dfdb9791ccd2">
                  <SHORT-NAME>APAParkInOffsetType_MComposition_APAParkInOffsetType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAParkInOffsetType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAParkInOffsetType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2080c37402f63e318f7efcea81bdd7c2">
                  <SHORT-NAME>APARemShifGear_MComposition_APARemShifGear</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APARemShifGear</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APARemShifGear</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="80a0e96e9c2f3f54a1fefb881f5a9f75">
                  <SHORT-NAME>APASWReq_MComposition_APASWReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASWReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASWReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8fb3c07bc67631cc848c68a34d87c76c">
                  <SHORT-NAME>APASW_MComposition_APASW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASW</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="918a0a2c9b2933a98111a6328f569690">
                  <SHORT-NAME>APASpdMdSwSts_MComposition_APASpdMdSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASpdMdSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASpdMdSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bf2f17b5113e3e31bb4af6b231600c3c">
                  <SHORT-NAME>AVMDspReq_MComposition_AVMDspReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVMDspReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVMDspReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a03887b2c5f03b4ea1106b77fc6355d7">
                  <SHORT-NAME>AVMSt_MComposition_AVMSt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVMSt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVMSt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd2639684bf73ced879a364b9de4e425">
                  <SHORT-NAME>AVPMapRutMgIDtReq_MComposition_AVPMapRutMgIDtReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVPMapRutMgIDtReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVPMapRutMgIDtReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5ef822c894f7340189c534b233d6e6bf">
                  <SHORT-NAME>AutoLaneChngSetReq_MComposition_AutoLaneChngSetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngSetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngSetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="99f1ff3df2c0303d9d8c644d4c3febd7">
                  <SHORT-NAME>AutoLaneChngSwReq_MComposition_AutoLaneChngSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="935b172a41993dad94fdac58022b29ab">
                  <SHORT-NAME>AutoLaneChngVcCmd_MComposition_AutoLaneChngVcCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngVcCmd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngVcCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="da4d461e89dd38b28f01d5a5bae518c7">
                  <SHORT-NAME>AutoMainBeamLghtOn_MComposition_AutoMainBeamLghtOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoMainBeamLghtOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoMainBeamLghtOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d61fdc8f0463398eb49c9cc37f7937b9">
                  <SHORT-NAME>AutoMainBeamLghtReq_MComposition_AutoMainBeamLghtReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoMainBeamLghtReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoMainBeamLghtReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e29d390f691538a69182cfeb7d0fc890">
                  <SHORT-NAME>BSDSelReq_MComposition_BSDSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/BSDSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/BSDSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b8bfa21c5adf3ffbb44760b0847877ec">
                  <SHORT-NAME>BaseLineLen_MComposition_BaseLineLen</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/BaseLineLen</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/BaseLineLen</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="488a1a833e1b3142be5c573187e47f9e">
                  <SHORT-NAME>CANprotocolinternalversion_MComposition_CANprotocolinternalversion</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CANprotocolinternalversion</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CANprotocolinternalversion</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48220b9da1df3c75aeec6cd92b0aa157">
                  <SHORT-NAME>CCSpdVcCmdCnfm_MComposition_CCSpdVcCmdCnfm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCSpdVcCmdCnfm</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCSpdVcCmdCnfm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a372ea53d44d36a3ad3031e13e41698c">
                  <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd_MComposition_CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCSpdlVcCmdSwReqDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCSpdlVcCmdSwReqDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f0be853aeb9038caa077c7e5cda75931">
                  <SHORT-NAME>CCU_100ms_Group02_MComposition_CCU_100ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b18afd6b5f3c3753959a7192acc8993d">
                  <SHORT-NAME>CCU_100ms_Group07_MComposition_CCU_100ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group07</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c001b2a0de91326b9c808cc26646cafa">
                  <SHORT-NAME>CCU_100ms_Group11_MComposition_CCU_100ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6f0b4ca88ef63bc6a88e7bc6317b3911">
                  <SHORT-NAME>CSFStsForEdr_MComposition_CSFStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CSFStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CSFStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="75f35ca9fc613c55a4d1abe89c5930bb">
                  <SHORT-NAME>ChrgPwrReq_kW_MComposition_ChrgPwrReq_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ChrgPwrReq_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ChrgPwrReq_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e4610c091d043693a7cd1f8d2b0a990a">
                  <SHORT-NAME>ChrgReq_flg_MComposition_ChrgReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ChrgReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ChrgReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1cddb6f264b23659b6c4e830322dbd27">
                  <SHORT-NAME>ClstrDspdVehSpd_mph_MComposition_ClstrDspdVehSpd_mph</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ClstrDspdVehSpd_mph</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ClstrDspdVehSpd_mph</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3c6c8f4f10ef35e99d829464b764343b">
                  <SHORT-NAME>ComKeyEnbReq_MComposition_ComKeyEnbReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ComKeyEnbReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ComKeyEnbReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5efed9db72ee3424a5812f14b19f68d3">
                  <SHORT-NAME>D2DPriETClanSwReqResps_MComposition_D2DPriETClanSwReqResps</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DPriETClanSwReqResps</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DPriETClanSwReqResps</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="31c045faf61a3aa9854cfe7c328c2f22">
                  <SHORT-NAME>D2DPriETClanSwReq_MComposition_D2DPriETClanSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DPriETClanSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DPriETClanSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e89c36142a43cb89a1b6eec07f086c5">
                  <SHORT-NAME>D2DSwReqResps_MComposition_D2DSwReqResps</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSwReqResps</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSwReqResps</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8084bc4c894231cfb32fa5a53d00f50c">
                  <SHORT-NAME>D2DSwReq_MComposition_D2DSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0a14e523ea63178912909d98b4987df">
                  <SHORT-NAME>D2DSysSts_MComposition_D2DSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c07f13a694138fbb2b596612930b541">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0_MComposition_DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_0</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8e34bd05f3153e609337dbc1772aac1c">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1_MComposition_DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="777a732accde37058e9f46240b5f376e">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2_MComposition_DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e837d934b46e3c0cba88c744a020633e">
                  <SHORT-NAME>DMSCameraFps_IMM_MComposition_DMSCameraFps_IMM</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DMSCameraFps_IMM</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DMSCameraFps_IMM</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4e35ebba73fa300ba4b925e1ff717573">
                  <SHORT-NAME>DOWSelReq_MComposition_DOWSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DOWSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DOWSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8807141721f73425b578bcfb51962514">
                  <SHORT-NAME>DTCInfomationIPD_MComposition_DTCInfomationIPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DTCInfomationIPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DTCInfomationIPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="947dfc1111f63b37b3492f2dc2da8ac9">
                  <SHORT-NAME>DetourMsgReq_MComposition_DetourMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DetourMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DetourMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45a6be5bc9f63b30aef17cc3f4c53641">
                  <SHORT-NAME>DfstOnDspCmd_MComposition_DfstOnDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DfstOnDspCmd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DfstOnDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3dff064b6653062b37e8814b4f328e4">
                  <SHORT-NAME>DiffAgeInfo_MComposition_DiffAgeInfo</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DiffAgeInfo</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DiffAgeInfo</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8074452e4ac83f368b4f076ff5fd54c5">
                  <SHORT-NAME>DiffDataLinkBroken_MComposition_DiffDataLinkBroken</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DiffDataLinkBroken</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DiffDataLinkBroken</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd1bb85062ed30bc9cfbae4927d293c0">
                  <SHORT-NAME>DircnIndLghtMdSts_MComposition_DircnIndLghtMdSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DircnIndLghtMdSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DircnIndLghtMdSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="30826b587b413bc6b834b97153608118">
                  <SHORT-NAME>DircnIndLghtSwSts_MComposition_DircnIndLghtSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DircnIndLghtSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DircnIndLghtSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc1f7b3e78533b45a15e08611972a038">
                  <SHORT-NAME>DistSinceTrgtCamr_MComposition_DistSinceTrgtCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DistSinceTrgtCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DistSinceTrgtCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e53f640a09ed333d9bb7b8d3d75f047a">
                  <SHORT-NAME>DistToTrfcJamNav_MComposition_DistToTrfcJamNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DistToTrfcJamNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DistToTrfcJamNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="379cb95c11543f139ab67dc44b893a6a">
                  <SHORT-NAME>DownVelocityRTK_MComposition_DownVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DownVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DownVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2ffe5213f3503617a482485acd39ad23">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm_MComposition_DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlFilt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlFilt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d1820f16e4fc33a0bcc08f86683a241e">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm_MComposition_DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlRawCap_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlRawCap_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5bcf0ca05156362ab37391b6ed557ff8">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm_MComposition_DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlRaw_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlRaw_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1105f48ba59730f795e2d0ad8ed714ef">
                  <SHORT-NAME>DrvrDstrctnSts_MComposition_DrvrDstrctnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvrDstrctnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvrDstrctnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c98461a19daa3495bcd378927b119996">
                  <SHORT-NAME>DrvrFtgLvl_MComposition_DrvrFtgLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvrFtgLvl</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvrFtgLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1eee4d6d36f831949f679b96af7e123b">
                  <SHORT-NAME>DsblICE_flg_MComposition_DsblICE_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DsblICE_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DsblICE_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f3c8c1d00b013b9b8bae19ab1cf89d10">
                  <SHORT-NAME>DsblISG_flg_MComposition_DsblISG_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DsblISG_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DsblISG_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4d067cd51a7334aeb4d5029e1b01d43e">
                  <SHORT-NAME>DschrgOptMaxPwr_MComposition_DschrgOptMaxPwr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DschrgOptMaxPwr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DschrgOptMaxPwr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="890c4c9b355a31278f980014c8385c2c">
                  <SHORT-NAME>ECM_010ms_Group00_MComposition_ECM_010ms_Group00</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_010ms_Group00</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_010ms_Group00</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="10a5e507af8e3598be2a033964f82479">
                  <SHORT-NAME>ECM_25ms_Group36_MComposition_ECM_25ms_Group36</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_25ms_Group36</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_25ms_Group36</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7cd3a7461a5337b28bfcb32a7126aaab">
                  <SHORT-NAME>ECM_500ms_group02_MComposition_ECM_500ms_group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_500ms_group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_500ms_group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9ad871f247fd322ab6dadd2642279c3d">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03_MComposition_ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_ZONE_020ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_ZONE_020ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="016626820865344c911d7d2d77ae099c">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09_MComposition_ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_ZONE_050ms_Group09</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_ZONE_050ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aa38d55fab4b3a3d9f264602ab5fe500">
                  <SHORT-NAME>EDUClntTemV_MComposition_EDUClntTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUClntTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUClntTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="04819378437a389bacc56bfc7d0af625">
                  <SHORT-NAME>EDUClntTem_MComposition_EDUClntTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUClntTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUClntTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f10886b18853d7d9347523fb79acd62">
                  <SHORT-NAME>EDUOilTemV_MComposition_EDUOilTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUOilTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUOilTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3183c0d463983482836018190831d4d1">
                  <SHORT-NAME>EDUOilTem_MComposition_EDUOilTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUOilTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUOilTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="32a68a09630b3ae8864eecd33c8f3392">
                  <SHORT-NAME>ELKDspCmd_MComposition_ELKDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="40f62e2e0f863dbb8affe9bc72b5bcec">
                  <SHORT-NAME>ELKSwReq_MComposition_ELKSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="664a3ad1566d357b8b4a8c149effcb23">
                  <SHORT-NAME>ELKSysFltSts_MComposition_ELKSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="20efca661815340599802d296f0ba168">
                  <SHORT-NAME>ELKWarning_MComposition_ELKWarning</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKWarning</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKWarning</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b21d8832f7f2343183509959d95fdd48">
                  <SHORT-NAME>EORWarningEvtSts_MComposition_EORWarningEvtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EORWarningEvtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EORWarningEvtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="11db1ca88d6538d8a80e4c345d97156f">
                  <SHORT-NAME>EPSAvlbly_MComposition_EPSAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPSAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPSAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d2f32cd48a1237a09979bee4ca6992c0">
                  <SHORT-NAME>EPSCTTX_MComposition_EPSCTTX</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPSCTTX</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPSCTTX</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8b54bc9db37b33d9a3c3cb4346fa2c6d">
                  <SHORT-NAME>EPS_010ms_Group03_MComposition_EPS_010ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_010ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_010ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9088ab782a139809e53adfb6dcc18b3">
                  <SHORT-NAME>EPS_10ms_Group01_MComposition_EPS_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a18cfb5dc94f3c2286da16c51bea6ee1">
                  <SHORT-NAME>EPS_10ms_Group02_MComposition_EPS_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fb6ba1d1e9403e2c91e0cfbf74de15e7">
                  <SHORT-NAME>EPS_10ms_Group05_MComposition_EPS_10ms_Group05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group05</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b9237e040813986a08d78063bed8636">
                  <SHORT-NAME>EPS_20ms_Group03_MComposition_EPS_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc0f13a77b5b3bdf9752391869e8afd3">
                  <SHORT-NAME>EPTClntPumpSta_MComposition_EPTClntPumpSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPTClntPumpSta</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPTClntPumpSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d112c2f71bc93e13990465d6bb202eac">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd_MComposition_EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPTElecWtrPumpActuSpd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPTElecWtrPumpActuSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="65aeb6a19c0f352bbe84caaba34eb4ef">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW_MComposition_ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCBrkRgnPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCBrkRgnPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cc525ad99e5e3bb99eaabc9e500d5441">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW_MComposition_ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCChrgPwrLmtPeak_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCChrgPwrLmtPeak_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e4c98d09548a3265ad2212763755b30c">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW_MComposition_ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCChrgPwrLmtWhl_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCChrgPwrLmtWhl_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b634092d55b9302dba463b77645fba6d">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW_MComposition_ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCDsChrgPwrLmtPeak_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCDsChrgPwrLmtPeak_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cf31f00fe83f3df0858c3bfc9e9acdb1">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW_MComposition_ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCDsChrgPwrLmtWhl_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCDsChrgPwrLmtWhl_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f4ffcdd197ce3b4cad02f43e29debbb4">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg_MComposition_ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCEmgcyPwrDwn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCEmgcyPwrDwn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="819a03c8c6d1399a8d7f5a03e069412c">
                  <SHORT-NAME>ERCFCOReq_flg_MComposition_ERCFCOReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCFCOReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCFCOReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="473d4c83e8f13346a064deec76cf2f27">
                  <SHORT-NAME>ERCHVAllwd_flg_MComposition_ERCHVAllwd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCHVAllwd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCHVAllwd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4047785f7f7032e394765e5f6127f467">
                  <SHORT-NAME>ERCHVHldReq_flg_MComposition_ERCHVHldReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCHVHldReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCHVHldReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc55e9998c363be7a4817e20d940bb8b">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW_MComposition_ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCMaxChrgPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCMaxChrgPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1853927f10ec3ae5a7cb8934c55225a9">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW_MComposition_ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCMaxDschgPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCMaxDschgPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5fd34c6bb22535d488d77690717dfee9">
                  <SHORT-NAME>ESCLPwrSts_MComposition_ESCLPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESCLPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESCLPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d100c7649323365951292ded1dac095">
                  <SHORT-NAME>ESFStsForEdr_MComposition_ESFStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESFStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESFStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="466f1e4879bd3dde8cafccaedf5e16eb">
                  <SHORT-NAME>ESSAdoWrnngDspCmd_MComposition_ESSAdoWrnngDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSAdoWrnngDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSAdoWrnngDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="95cb1203020d3edcbb0cece3417667f3">
                  <SHORT-NAME>ESSAdoWrnngReq_MComposition_ESSAdoWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSAdoWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSAdoWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ad07be04650b3e78bd0f51a0d6e56833">
                  <SHORT-NAME>ESSDspCmd_MComposition_ESSDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c2365e18fa99370ea3ae19ce8b551d04">
                  <SHORT-NAME>ESS_100ms_Group58_MComposition_ESS_100ms_Group58</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESS_100ms_Group58</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESS_100ms_Group58</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c6fadc7afd2337c8ad95ee1a16de2b3">
                  <SHORT-NAME>ESSswReq_MComposition_ESSswReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSswReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSswReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7af2bc0ba7e23a8d80cdabfbe294570f">
                  <SHORT-NAME>EVMd_flg_MComposition_EVMd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EVMd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EVMd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7fdc6b912fe33a86beff67ad66ae2904">
                  <SHORT-NAME>EastVelocityRTK_MComposition_EastVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EastVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EastVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2222d456569b30f6a1130c66e53272e8">
                  <SHORT-NAME>ElecPwrDistbnScene_MComposition_ElecPwrDistbnScene</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ElecPwrDistbnScene</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ElecPwrDistbnScene</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4562d75fceeb3fbdba40dde638c152a9">
                  <SHORT-NAME>En12VoltStrMotCmddOn_MComposition_En12VoltStrMotCmddOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/En12VoltStrMotCmddOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/En12VoltStrMotCmddOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="91ed0b2bd2eb342885d85984b9358886">
                  <SHORT-NAME>EngBrkTqMax_Nm_MComposition_EngBrkTqMax_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngBrkTqMax_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngBrkTqMax_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6b29be6e036c3f538059d6537c09338b">
                  <SHORT-NAME>EngFastTqReq_Nm_MComposition_EngFastTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFastTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFastTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a62a08696c93abeafbaf9efdde56ec2">
                  <SHORT-NAME>EngFastTqTypReq_enum_MComposition_EngFastTqTypReq_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFastTqTypReq_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFastTqTypReq_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3c36e09011e3f86a03b8e9c479e4b35">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm_MComposition_EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFlexplateTqFstTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFlexplateTqFstTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d57105c253f23cd0bc4b27191a121807">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm_MComposition_EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFlexplateTqSlowTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFlexplateTqSlowTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7ed92c58eade3468bcca8db75a723032">
                  <SHORT-NAME>EngPhsAng_deg_MComposition_EngPhsAng_deg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngPhsAng_deg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngPhsAng_deg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5c0a124cf6a13aac90879a24a2466827">
                  <SHORT-NAME>EngSlowTqReq_Nm_MComposition_EngSlowTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngSlowTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngSlowTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="81296e3370563bfca3ea5df784198b5d">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg_MComposition_EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngSpdSafe4EngStrt_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngSpdSafe4EngStrt_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f61ddec414b3d90b546660925f59ef3">
                  <SHORT-NAME>EngStallCnt_cnt_MComposition_EngStallCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStallCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStallCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="319eb49d32b63bd99989f9dd6909d80e">
                  <SHORT-NAME>EngStall_cnt_MComposition_EngStall_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStall_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStall_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="826a2ff7ba1f32a294b8c27fbc29a8ae">
                  <SHORT-NAME>EngStopReqCfmd_flg_MComposition_EngStopReqCfmd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStopReqCfmd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStopReqCfmd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="58c5196d23b13796b37551d758732b7a">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt_MComposition_EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtDampSlipFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtDampSlipFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4ab1bf003a5a34a5ae00bc3077246a0a">
                  <SHORT-NAME>EngStrtFailCnt_cnt_MComposition_EngStrtFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bce12c6a03593b3192a2657225967639">
                  <SHORT-NAME>EngStrtFail_cnt_MComposition_EngStrtFail_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtFail_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtFail_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb7c9317bb0835549bdad0917e1b111b">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt_MComposition_EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtNoCapFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtNoCapFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="727b5b9fbcfa39efa0026ab511b7e6ef">
                  <SHORT-NAME>EngStrtReq_flg_MComposition_EngStrtReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0f5be54814de3b15bea12e173f470f9a">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt_MComposition_EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtStuckFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtStuckFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="18af3f3b386e3385bb4910b92327a1a6">
                  <SHORT-NAME>EvtPotclSigIPD1_MComposition_EvtPotclSigIPD1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="948ffd29e4743f77bfda5a1828b658ac">
                  <SHORT-NAME>EvtPotclSigIPD2_MComposition_EvtPotclSigIPD2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f18c75d0285b3f33ad47b1f179c67d39">
                  <SHORT-NAME>EvtPotclSigIPD3_MComposition_EvtPotclSigIPD3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d28c6940125833a9a4c8222dab3d5c4d">
                  <SHORT-NAME>EvtPotclSigIPD4_MComposition_EvtPotclSigIPD4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD4</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e81778854fc83c199292a7845653e326">
                  <SHORT-NAME>EvtPotclSigIPD5_MComposition_EvtPotclSigIPD5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD5</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2700ca3ecc2636ee9dda85d35c5f1e37">
                  <SHORT-NAME>EvtPotclSigIPD6_MComposition_EvtPotclSigIPD6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD6</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="81bacaa17b3037558c52b7efde2ac0f0">
                  <SHORT-NAME>EvtPotclSigIPD7_MComposition_EvtPotclSigIPD7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD7</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f5f9e6fc30637cf834e2c525aff1f98">
                  <SHORT-NAME>EvtPotclSigIPD8_MComposition_EvtPotclSigIPD8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD8</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bb48af2bdbcc387db0b76631dbda32d0">
                  <SHORT-NAME>FCTBSysFltSts_ADAS_MComposition_FCTBSysFltSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTBSysFltSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTBSysFltSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="663a8e964b17313793cc97a80afbd538">
                  <SHORT-NAME>FCTBSysFltSts_MComposition_FCTBSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTBSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTBSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="71e2f15ff2c93452a7bdefd7f84f874c">
                  <SHORT-NAME>FCTSwSts_ADAS_MComposition_FCTSwSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSwSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSwSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5f297ee31b2b3c26ab5a2c306e3ffd17">
                  <SHORT-NAME>FCTSwSts_MComposition_FCTSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cabe6fa0aae336a69e6f13ba7d397790">
                  <SHORT-NAME>FCTSysFltSts_ADAS_MComposition_FCTSysFltSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysFltSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysFltSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9386116a434137a59b9a99c580c72c92">
                  <SHORT-NAME>FCTSysFltSts_MComposition_FCTSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f7f04934ed743b93818ac0f781c7f558">
                  <SHORT-NAME>FCTSysSelReq_MComposition_FCTSysSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0fe46560fe453607b5fb797aa5879730">
                  <SHORT-NAME>FCWDspCmd_MComposition_FCWDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b5e86eee7faa358cbc2166c7493b751a">
                  <SHORT-NAME>FCWSnstvtLvlReq_MComposition_FCWSnstvtLvlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSnstvtLvlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSnstvtLvlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd98629542b03420a2e8ec30c51059ee">
                  <SHORT-NAME>FCWSnstvtLvl_MComposition_FCWSnstvtLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSnstvtLvl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSnstvtLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4aa57f04b1a53552a6743dfd5c759332">
                  <SHORT-NAME>FCWSwReq_MComposition_FCWSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d8c1e041c7c32f9a91dfc974bdf6e84">
                  <SHORT-NAME>FCWSysFltSts_MComposition_FCWSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e456f51330a93bf38080b004ba0e7b73">
                  <SHORT-NAME>FCWrnngSts_MComposition_FCWrnngSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWrnngSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWrnngSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c450a78830db3cba85f82dc9bbccd848">
                  <SHORT-NAME>FDRPwrSts_MComposition_FDRPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FDRPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FDRPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c039f9aef0f535728527422376f1f8c9">
                  <SHORT-NAME>FDR_100ms_Group01_MComposition_FDR_100ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FDR_100ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FDR_100ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5be9e0db55023034b2448694a03c2e26">
                  <SHORT-NAME>FLDircnLghtSts_MComposition_FLDircnLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDircnLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDircnLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7f0a1a54356315e8ee9823f3e9749b3">
                  <SHORT-NAME>FLDoorHndlPESwtActv_MComposition_FLDoorHndlPESwtActv</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDoorHndlPESwtActv</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDoorHndlPESwtActv</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="df850ea0022f358d92a32ed36864277d">
                  <SHORT-NAME>FLDoorOpenSts_MComposition_FLDoorOpenSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDoorOpenSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDoorOpenSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cab460d1e443321792592ea07be765af">
                  <SHORT-NAME>FLObsRng_MComposition_FLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a459b28679543837886cbf2098c6c4a2">
                  <SHORT-NAME>FLSObsRng_MComposition_FLSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="63b5d42abec63c91b34231ef19a80f9b">
                  <SHORT-NAME>FLSUSSSts_MComposition_FLSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b91337970eb93eb3b9f51a60132da821">
                  <SHORT-NAME>FLSideObsRng_MComposition_FLSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89adb67168403b4fa6e968bad996de45">
                  <SHORT-NAME>FLTirePrsV_MComposition_FLTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4c03140570ce31f6a781f529b15f26be">
                  <SHORT-NAME>FLTirePrs_MComposition_FLTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="276ea3b1c56a384b9ea3040a3a83117e">
                  <SHORT-NAME>FLTireSts_MComposition_FLTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7b6a3497616533b4bfdea0836be08ab1">
                  <SHORT-NAME>FLTireTemV_MComposition_FLTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="73c6dd09c81c375ab47c885034fe32c2">
                  <SHORT-NAME>FLTireTem_MComposition_FLTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3cc585ffe6ac37d6bafb534c1ee82b45">
                  <SHORT-NAME>FLUSSSts_MComposition_FLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9ef5812466313a6fba5e48838e8cdf6d">
                  <SHORT-NAME>FLiDARPwrSts_MComposition_FLiDARPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLiDARPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLiDARPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6b38c7138e023dd5b6d2d7567f069e77">
                  <SHORT-NAME>FMLUSSSts_MComposition_FMLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FMLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FMLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ef5ed4145fbb3ac1946baa5cdffb2328">
                  <SHORT-NAME>FMRUSSSts_MComposition_FMRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FMRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FMRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3347b52f4613caa9a5c4226ca6e76d7">
                  <SHORT-NAME>FOTAStatusValid_MComposition_FOTAStatusValid</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTAStatusValid</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTAStatusValid</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0fcb8f098b3831bfbcdc60afa5e2cdd0">
                  <SHORT-NAME>FOTAStatus_MComposition_FOTAStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTAStatus</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTAStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6e87c6dcdb313e78b5a6ef07021128b6">
                  <SHORT-NAME>FOTATargetValid_MComposition_FOTATargetValid</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTATargetValid</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTATargetValid</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="359f40727cc634318b26339ac4066624">
                  <SHORT-NAME>FOTATarget_MComposition_FOTATarget</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTATarget</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTATarget</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="98243c65e43f3553bcfff7fe55ea53f9">
                  <SHORT-NAME>FRDircnLghtSts_MComposition_FRDircnLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDircnLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDircnLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34a4747030b73480a91be0fc930fa1dd">
                  <SHORT-NAME>FRDoorHndlPESwtActv_MComposition_FRDoorHndlPESwtActv</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDoorHndlPESwtActv</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDoorHndlPESwtActv</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a7d4ea5a3479335c8d25e3f2108f1221">
                  <SHORT-NAME>FRDoorOpenSts_MComposition_FRDoorOpenSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDoorOpenSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDoorOpenSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b0193515502537a6b5b523f9543e4775">
                  <SHORT-NAME>FRObsRng_MComposition_FRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9047804edba53949b7d3fa6895310530">
                  <SHORT-NAME>FRSObsRng_MComposition_FRSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1b6bda2643e13c7784411b2c9a9b1223">
                  <SHORT-NAME>FRSUSSSts_MComposition_FRSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d220a2bff15232c99615943cd57c092d">
                  <SHORT-NAME>FRSideObsRng_MComposition_FRSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="217e33aa6a4f3c3897d5d46e4e058525">
                  <SHORT-NAME>FRTirePrsV_MComposition_FRTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e8e8e14efd3313f9ed34abc8477a127">
                  <SHORT-NAME>FRTirePrs_MComposition_FRTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="145100842723300ba5f7d541aac69fc3">
                  <SHORT-NAME>FRTireSts_MComposition_FRTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="62adc6fbf53c31588086cd54b2cab9a5">
                  <SHORT-NAME>FRTireTemV_MComposition_FRTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b83d02f4e033c91a26ca8d84dd10f2e">
                  <SHORT-NAME>FRTireTem_MComposition_FRTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6b5ea8f3f22b38d6b50d2a38e3bc66b7">
                  <SHORT-NAME>FRUSSSts_MComposition_FRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fdcde99926a835048c8c794b666cc7f7">
                  <SHORT-NAME>FVCM_10ms_Group01_MComposition_FVCM_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FVCM_10ms_Group01</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FVCM_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="972775e6356135fa88a797d2458ffbfe">
                  <SHORT-NAME>FVCM_20ms_Group02_MComposition_FVCM_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FVCM_20ms_Group02</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FVCM_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="17a388441d8a3c59a5f0546d16e780a2">
                  <SHORT-NAME>FrtCamrHeatCtrl_MComposition_FrtCamrHeatCtrl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCamrHeatCtrl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCamrHeatCtrl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="14804923a87c3df499b3efb70ed6baf4">
                  <SHORT-NAME>FrtCamrHeatSts_MComposition_FrtCamrHeatSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCamrHeatSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCamrHeatSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="518870c8c47331f3842d7c2caaa17778">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd_MComposition_FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCarGoNotfrDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCarGoNotfrDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a949ab1d7b8b3b9fa790f322f40e0321">
                  <SHORT-NAME>FrtCarGoNotfrSwReq_MComposition_FrtCarGoNotfrSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCarGoNotfrSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCarGoNotfrSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f1769b6e153a374888fb9ccb3eb11c1c">
                  <SHORT-NAME>FrtMidLObsRng_MComposition_FrtMidLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtMidLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtMidLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2695e98df67135cab9f3f58587d6f21e">
                  <SHORT-NAME>FrtMidRObsRng_MComposition_FrtMidRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtMidRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtMidRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="484710b65be8361197e886f030b46e50">
                  <SHORT-NAME>FrtObsDist_MComposition_FrtObsDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtObsDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtObsDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5ee3dd05a463c2fa9de7a3f5b5b93cb">
                  <SHORT-NAME>FrtPDCAudWrnng_MComposition_FrtPDCAudWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtPDCAudWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtPDCAudWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7f48f3bc2efd3295986660b4dac00cc1">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU_MComposition_FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtPsngDoorOpenSts_LHZCU</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtPsngDoorOpenSts_LHZCU</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f29b9416f4753af089b76b5d1a834aac">
                  <SHORT-NAME>FrtTireStdPrs_MComposition_FrtTireStdPrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtTireStdPrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtTireStdPrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c43104a5817c31b690675b3b7200a7a7">
                  <SHORT-NAME>FrtWindShldSfcTem_MComposition_FrtWindShldSfcTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSfcTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSfcTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="728e3c066b663026a857da30cd60b85c">
                  <SHORT-NAME>FrtWindShldSurndHmdty_MComposition_FrtWindShldSurndHmdty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSurndHmdty</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSurndHmdty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="61ad978a69413d019920ae733c1f465c">
                  <SHORT-NAME>FrtWindShldSurndTem_MComposition_FrtWindShldSurndTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSurndTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSurndTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="542dac96377c330fbce1249021a4a7c6">
                  <SHORT-NAME>FrtWiperSpd_MComposition_FrtWiperSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWiperSpd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWiperSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="09c4943a77ec3ba8a7c7cf8695ca47cd">
                  <SHORT-NAME>FrtWiperSwSts_MComposition_FrtWiperSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWiperSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWiperSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="502c43e455b23a52afeea665e2d7a611">
                  <SHORT-NAME>FuCutReq_enum_MComposition_FuCutReq_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FuCutReq_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FuCutReq_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="705d57ee2f593013911d347470faff61">
                  <SHORT-NAME>FulCutDMFPrdtn_flg_MComposition_FulCutDMFPrdtn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutDMFPrdtn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutDMFPrdtn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="708dcd19452735d0bfea59257de49475">
                  <SHORT-NAME>FulCutEngStall_flg_MComposition_FulCutEngStall_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutEngStall_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutEngStall_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="71a33f222e8d391a9e76f9bb5bbe45dd">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg_MComposition_FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutLosCommWthEMS_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutLosCommWthEMS_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4972c3c64586390a9af1b6dcc8fab2c9">
                  <SHORT-NAME>GNSSAntennasBroken_MComposition_GNSSAntennasBroken</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/GNSSAntennasBroken</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/GNSSAntennasBroken</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59a1a2d0051c3ea8addb768d949fd563">
                  <SHORT-NAME>GNSSAntennasInfo_MComposition_GNSSAntennasInfo</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/GNSSAntennasInfo</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/GNSSAntennasInfo</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0cf8b908ff4136069d8019203adcc1d8">
                  <SHORT-NAME>HCUSAMTqReq_Nm_MComposition_HCUSAMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HCUSAMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HCUSAMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="97a82a08c1073d79b989e0ce43d7f316">
                  <SHORT-NAME>HORWarningEvtSts_MComposition_HORWarningEvtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HORWarningEvtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HORWarningEvtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="76ca53a0bfcf3a289eb2a7173d2c759e">
                  <SHORT-NAME>HPPFnSts_MComposition_HPPFnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPFnSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPFnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7ce17c22385b3b7593da3b0644d9fcd6">
                  <SHORT-NAME>HPPInBmtSts_MComposition_HPPInBmtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPInBmtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPInBmtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="92662e8928613c3ab2c82bc012292e82">
                  <SHORT-NAME>HPPMapBuildSts_MComposition_HPPMapBuildSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPMapBuildSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPMapBuildSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a48b683f9d9c3e38b656fa69f88f3d32">
                  <SHORT-NAME>HPPOnRoutSts_MComposition_HPPOnRoutSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPOnRoutSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPOnRoutSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ab1c3c13eca23f5cb1d41fb682956278">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst_MComposition_HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HmdtySnsrHdwrFltPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HmdtySnsrHdwrFltPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6e167c94689a33468f891289c8dfb7c9">
                  <SHORT-NAME>IACCOvTSuppresCmd_MComposition_IACCOvTSuppresCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCOvTSuppresCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCOvTSuppresCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca08286294643242ad90e65e5f70db44">
                  <SHORT-NAME>IACCOvTSuppresSwReq_MComposition_IACCOvTSuppresSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCOvTSuppresSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCOvTSuppresSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="031128ef74273080bf8a6a3ca1ad25d1">
                  <SHORT-NAME>IACCPreMsgReq_MComposition_IACCPreMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c03c2950bde234d68dc26aa66e93e793">
                  <SHORT-NAME>IACCPreSpdLimtCmd_MComposition_IACCPreSpdLimtCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreSpdLimtCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreSpdLimtCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="129dc1b835633756bb58331b3d2c4759">
                  <SHORT-NAME>IACCPreSpdLimtSwReq_MComposition_IACCPreSpdLimtSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreSpdLimtSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreSpdLimtSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3f901738d4ae3071a53a1f546a4608b5">
                  <SHORT-NAME>IAMAvlbly_MComposition_IAMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8eba2a4791e5342291a23080df136509">
                  <SHORT-NAME>IAMReststs_MComposition_IAMReststs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAMReststs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAMReststs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="737b616934273eb7917a5f27de036205">
                  <SHORT-NAME>IAM_100ms_Group08_MComposition_IAM_100ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="80c9513f1e80300f9dd30ebde44325bf">
                  <SHORT-NAME>IAM_100ms_Group18_MComposition_IAM_100ms_Group18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0cd9d339387839a1902f6a6dce45ddea">
                  <SHORT-NAME>IAM_100ms_Group56_MComposition_IAM_100ms_Group56</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group56</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group56</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a0b1711e34c3eb6ab0f16dd44f9983d">
                  <SHORT-NAME>IAM_20ms_Group32_MComposition_IAM_20ms_Group32</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_20ms_Group32</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_20ms_Group32</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c2939e061c1632f8b46752bb6c23d064">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13_MComposition_IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cbb63d85512e3b479998cfd400d61db1">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34_MComposition_IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group34</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group34</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="362537bfb6fc3cda9b4e4dcba632264f">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35_MComposition_IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group35</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group35</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e0b5c7b62fef363884f261f1c28366f2">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40_MComposition_IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group40</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group40</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dec9fcc3b2d73c63b591db2c94aa205f">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57_MComposition_IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group57</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group57</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bb90a510761333d1b4464f8f630efa10">
                  <SHORT-NAME>IBS_100ms_Group15_MComposition_IBS_100ms_Group15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_100ms_Group15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_100ms_Group15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c8e26f6e76133c6bb769d5abb485208d">
                  <SHORT-NAME>IBS_10ms_Group01_MComposition_IBS_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7dd92c91f7573709815bc01da464a7fb">
                  <SHORT-NAME>IBS_10ms_Group02_MComposition_IBS_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5c77735abdca348ba927a3446e6846f0">
                  <SHORT-NAME>IBS_10ms_Group04_MComposition_IBS_10ms_Group04</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group04</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group04</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8966dd5708ea3849b7a156e9c845b142">
                  <SHORT-NAME>IBS_20ms_Group07_MComposition_IBS_20ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group07</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87fd8572e801385b9f75b683596b0e6b">
                  <SHORT-NAME>IBS_20ms_Group08_MComposition_IBS_20ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45fa8708d28c3416bced3ad3b591cef5">
                  <SHORT-NAME>IBS_20ms_Group09_MComposition_IBS_20ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group09</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f74842b2b28e3f87861c246589b68b59">
                  <SHORT-NAME>IBS_20ms_Group10_MComposition_IBS_20ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c043b76a8d173f35b90e63df958fb132">
                  <SHORT-NAME>IBS_20ms_Group11_MComposition_IBS_20ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a2d424ed4dd73970ae36e000473000b3">
                  <SHORT-NAME>IBS_20ms_Group12_MComposition_IBS_20ms_Group12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="53c6d7277c7c34cc9a2bb7f7339ea874">
                  <SHORT-NAME>IBS_20ms_Group13_MComposition_IBS_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b4a9dcfbe35a38818892dafeaa1fa669">
                  <SHORT-NAME>IBS_CHAvlbly_MComposition_IBS_CHAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_CHAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_CHAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aebb04a4a9023d118cec9907cf3c58b4">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08_MComposition_IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_ZONE_20ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_ZONE_20ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="37ce9886127e3228a59619df9eb2b090">
                  <SHORT-NAME>ICBAD_100ms_Group25_MComposition_ICBAD_100ms_Group25</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_100ms_Group25</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_100ms_Group25</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84dce385296a3659b6ce294b9e906ef1">
                  <SHORT-NAME>ICBAD_100ms_Group37_MComposition_ICBAD_100ms_Group37</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_100ms_Group37</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_100ms_Group37</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2fa9265f82073ef88f20fd2bf9012969">
                  <SHORT-NAME>ICBAD_10ms_Group01_MComposition_ICBAD_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_10ms_Group01</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b5796e7ff48e324ba3dcc42c32dc7963">
                  <SHORT-NAME>ICBAD_20ms_Group05_MComposition_ICBAD_20ms_Group05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group05</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84085db530a43b1e856e014713f4be83">
                  <SHORT-NAME>ICBAD_20ms_Group07_MComposition_ICBAD_20ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group07</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5bda22f906773525b528931e9bced4ee">
                  <SHORT-NAME>ICBAD_20ms_Group09_MComposition_ICBAD_20ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group09</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a172c3fb38735be8dbfe76b90273b08">
                  <SHORT-NAME>ICBAD_20ms_Group12_MComposition_ICBAD_20ms_Group12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group12</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a5eee6ef3f6a31838562f9b069c8977f">
                  <SHORT-NAME>ICBAD_20ms_Group13_MComposition_ICBAD_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group13</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2fe5c3a40f5336da8ecd28044972ddd9">
                  <SHORT-NAME>ICBAD_20ms_Group15_MComposition_ICBAD_20ms_Group15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group15</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3705f6cdeaed37f8882fd1fc34166979">
                  <SHORT-NAME>ICBAD_20ms_Group46_MComposition_ICBAD_20ms_Group46</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group46</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group46</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4cf19b618f1a38338d1dfd52d2085a7f">
                  <SHORT-NAME>ICBAD_20ms_Group48_MComposition_ICBAD_20ms_Group48</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group48</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group48</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45fa15bd1ec037c78a5823ff4aea339a">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20_MComposition_ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_ZONE_10ms_Group20</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_ZONE_10ms_Group20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e9f3b39c9f663e479a596cc615a164da">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13_MComposition_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_ZONE_20ms_Group13</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_ZONE_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59da49d1f84a30eeb48106750b136eb6">
                  <SHORT-NAME>ICBVC_100ms_Group01_MComposition_ICBVC_100ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e79d35823b0a3704a26f34a0933f7f5e">
                  <SHORT-NAME>ICBVC_100ms_Group19_MComposition_ICBVC_100ms_Group19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ddf1fd8735ea3e4597c285f47af450da">
                  <SHORT-NAME>ICBVC_100ms_Group80_MComposition_ICBVC_100ms_Group80</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group80</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group80</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a99983879b6b3d5a806619992cd80c01">
                  <SHORT-NAME>ICBVC_200ms_Group79_MComposition_ICBVC_200ms_Group79</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_200ms_Group79</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_200ms_Group79</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="646434a8959b3ad2991ab67591929a5d">
                  <SHORT-NAME>ICBVC_20ms_Group03_MComposition_ICBVC_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="37c96c14ca7734f5a779c04fd16261ff">
                  <SHORT-NAME>ICBVC_50ms_Group11_MComposition_ICBVC_50ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f2046d4c1613a9a8d1ef307b36d7c1a">
                  <SHORT-NAME>ICBVC_50ms_Group13_MComposition_ICBVC_50ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="60fcdf0f15173984b97581703f877d62">
                  <SHORT-NAME>ICBVC_50ms_Group158_MComposition_ICBVC_50ms_Group158</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group158</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group158</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4a0a2b40c5193fb683da8dd7938b8101">
                  <SHORT-NAME>ICBVC_50ms_Group256_MComposition_ICBVC_50ms_Group256</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group256</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group256</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3b3db349d8ac37ed8afb8790eecae4c0">
                  <SHORT-NAME>ICMDrvrDstcnSts_MComposition_ICMDrvrDstcnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrDstcnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrDstcnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5bf7bf53e0d6360093fa5d2a8a545315">
                  <SHORT-NAME>ICMDrvrFtgLvl_MComposition_ICMDrvrFtgLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrFtgLvl</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrFtgLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="72717ba3cd113ad6aa37c18d0b906410">
                  <SHORT-NAME>ICMDrvrPrst_MComposition_ICMDrvrPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="424d54e4aa31351cb1211ca71239bec2">
                  <SHORT-NAME>ICMEyeOnRoad_MComposition_ICMEyeOnRoad</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMEyeOnRoad</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMEyeOnRoad</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f33996d9def83b2997117ff076b02953">
                  <SHORT-NAME>ICMSwReq_Reserve16_MComposition_ICMSwReq_Reserve16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMSwReq_Reserve16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMSwReq_Reserve16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aeb19e767ec53160908b23d8b3b3cea9">
                  <SHORT-NAME>ICMSwReq_Reserve17_MComposition_ICMSwReq_Reserve17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMSwReq_Reserve17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMSwReq_Reserve17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a501e7315fe6344daf49f5764785d9a4">
                  <SHORT-NAME>ILCSwReq_MComposition_ILCSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ILCSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ILCSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7364ae2cefd53f75a2b0e11d44eb6b81">
                  <SHORT-NAME>IMM_50ms_Group02_MComposition_IMM_50ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IMM_50ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IMM_50ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6876f5ce3e7c364296af6715eb5758be">
                  <SHORT-NAME>IMU_SN_MComposition_IMU_SN</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IMU_SN</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IMU_SN</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="91e1c090e827351cb4a2f290256cf5cf">
                  <SHORT-NAME>IPDAVCamrHeatReq_MComposition_IPDAVCamrHeatReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAVCamrHeatReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAVCamrHeatReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c98f823728c3c9c9b78ef11618357cf">
                  <SHORT-NAME>IPDAlgFlag_MComposition_IPDAlgFlag</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAlgFlag</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAlgFlag</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e638eab846c3d26bc347ed38acfe054">
                  <SHORT-NAME>IPDAurixTemp_MComposition_IPDAurixTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAurixTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAurixTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="60d1df2def43339cac1bf0850d566c17">
                  <SHORT-NAME>IPDComKeyEnbResp_MComposition_IPDComKeyEnbResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDComKeyEnbResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDComKeyEnbResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="27b7b4c9485a395a8d617a7888fb71fe">
                  <SHORT-NAME>IPDDataId_MComposition_IPDDataId</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDDataId</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDDataId</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ff8b6d2929c53359b7c831ac52baa2d9">
                  <SHORT-NAME>IPDErrorCount_MComposition_IPDErrorCount</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDErrorCount</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDErrorCount</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="71f5abf91ac732bbbfc95aa6e9cce7f7">
                  <SHORT-NAME>IPDFailedReason_MComposition_IPDFailedReason</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDFailedReason</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDFailedReason</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f9b372cd8e263fc5a216d15d4990ff8d">
                  <SHORT-NAME>IPDIdentityResp_MComposition_IPDIdentityResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDIdentityResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDIdentityResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a18b204e5cef3708b4f5e7a9c272de4f">
                  <SHORT-NAME>IPDKeyStatus_MComposition_IPDKeyStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDKeyStatus</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDKeyStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fd13d5baa7e73efbacb8bb05bbeec25a">
                  <SHORT-NAME>IPDMCUTemp_MComposition_IPDMCUTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDMCUTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDMCUTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3f3b1eed79333400b810a086b10cf427">
                  <SHORT-NAME>IPDPCBTemp1_MComposition_IPDPCBTemp1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPCBTemp1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPCBTemp1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="46674168d7ab375ea177aabcb4f34317">
                  <SHORT-NAME>IPDPCBTemp2_MComposition_IPDPCBTemp2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPCBTemp2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPCBTemp2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a861f676cac63e069580032420667762">
                  <SHORT-NAME>IPDPMICTemp_MComposition_IPDPMICTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPMICTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPMICTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2ebd35a18d473956b9e42a617b3d34c5">
                  <SHORT-NAME>IPDPowerFailSwReq_MComposition_IPDPowerFailSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPowerFailSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPowerFailSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a0fa499dc693fd6bdd538a4bc8c2159">
                  <SHORT-NAME>IPDResetCnt_MComposition_IPDResetCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDResetCnt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDResetCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e8ee09e663b3302b8742b24e7800c916">
                  <SHORT-NAME>IPDSOCTemp_MComposition_IPDSOCTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDSOCTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDSOCTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="471a1c17b64831d4b3016a27c310a6fc">
                  <SHORT-NAME>IPDStsResp_MComposition_IPDStsResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDStsResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDStsResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6173830836813f4db8d30c3a49ee96c4">
                  <SHORT-NAME>IPDThermalWrnngLvl_MComposition_IPDThermalWrnngLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDThermalWrnngLvl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDThermalWrnngLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9fd3ab229eb435259ff6dcbf69ffefab">
                  <SHORT-NAME>IPDTripCntResetResp_MComposition_IPDTripCntResetResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripCntResetResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripCntResetResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8286fef74dbc34fe9536c577a8a21a39">
                  <SHORT-NAME>IPDTripCnt_MComposition_IPDTripCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripCnt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c902a41697a37bab146ca6422a74030">
                  <SHORT-NAME>IPDTripNvmTag_MComposition_IPDTripNvmTag</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripNvmTag</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripNvmTag</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5fca457f1a1a36b3ad076f15faeb58f3">
                  <SHORT-NAME>IPDWtrClntInltFlwReq_MComposition_IPDWtrClntInltFlwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltFlwReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltFlwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="602223726ee335db9241280688c39618">
                  <SHORT-NAME>IPDWtrClntInltReqFlg_MComposition_IPDWtrClntInltReqFlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltReqFlg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltReqFlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a605794367a53dcab790bfcb75d8e064">
                  <SHORT-NAME>IPDWtrClntInltTimeReq_MComposition_IPDWtrClntInltTimeReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltTimeReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltTimeReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="753ab759b46d33ec9bac022c9dc3653f">
                  <SHORT-NAME>IPD_20ms_Group43_MComposition_IPD_20ms_Group43</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group43</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group43</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a5280f3d038d3df596ffaea409891437">
                  <SHORT-NAME>IPD_20ms_Group60_MComposition_IPD_20ms_Group60</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group60</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group60</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc6ab95ac8a33a65bf8d458c12d07b3f">
                  <SHORT-NAME>IPD_20ms_Group64_MComposition_IPD_20ms_Group64</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group64</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group64</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7261fca2d6bf3036bbf9352167c19599">
                  <SHORT-NAME>IPD_20ms_Group67_MComposition_IPD_20ms_Group67</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group67</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group67</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a89ea0bd7e2f34de83b88fe4b3b455d1">
                  <SHORT-NAME>IPD_50ms_Group14_MComposition_IPD_50ms_Group14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_50ms_Group14</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_50ms_Group14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c14a212adc323a3fafddb4fea01d545a">
                  <SHORT-NAME>IPD_50ms_Group49_MComposition_IPD_50ms_Group49</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_50ms_Group49</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_50ms_Group49</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6704d503a7ba32c6931601c826b7f7ee">
                  <SHORT-NAME>IPD_NKI_BKPCANFD_MComposition_IPD_NKI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8e277a70c0a7304191595de015eb49bd">
                  <SHORT-NAME>IPD_NKI_CHCANFD_MComposition_IPD_NKI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="985194028d8d3f33ae0770eb45e073a7">
                  <SHORT-NAME>IPD_NKI_PTCANFD_MComposition_IPD_NKI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce075b5916bb33c99452da4e7303adaa">
                  <SHORT-NAME>IPD_NKI_SFCANFD_MComposition_IPD_NKI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78db9d1ff52536e29e5b90aa841ced53">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD_MComposition_IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2582da39039839d0aa9fe10cac998c98">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD_MComposition_IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a2ff06aa351351281fcc30268508d33">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD_MComposition_IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3b56663870cf3ff6bc737a4632ad072b">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD_MComposition_IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="42637cf617db30ea8fd2538898cb316c">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD_MComposition_IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e3e7aff5b51c388aa24efa40c378973c">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD_MComposition_IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="418adbd71592372089ecd87952a68a69">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD_MComposition_IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5825fb937c7d3aa5b03fe1cd9f8ec589">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD_MComposition_IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="967edde5270d3277904a6f7e87abcae3">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD_MComposition_IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f51fbe6fac7c375a83e0ab1b49423882">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD_MComposition_IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="407e7acacccf3b489d4bfa0e5df89252">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD_MComposition_IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="43ab1e32fd3a3db9bec536bbe4bd4c8d">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD_MComposition_IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c1137cd687b3c989da12c5ea1f4cc17">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD_MComposition_IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c64532f60323b03afb13ecc77e7ef2d">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD_MComposition_IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ecbd3016d10c3a0697b2730798ab4c62">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD_MComposition_IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5166e732bc6a36d68220943d70ea36f3">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD_MComposition_IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="52b35b658a9236b0aaa7f567f76904e9">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD_MComposition_IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3c1927e2caab3a2fa126e8476c3cf7de">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD_MComposition_IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de38cffd6197342f9cdade34ac8ed63c">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD_MComposition_IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="df29bc48c2b233cfbd5b2b94d8e6e139">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD_MComposition_IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
