                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b3026e200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnGPFLampOnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b30278500">
                  <SHORT-NAME>EnFuelCsumpEfncy</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelCsumpEfncy</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b30274f00">
                  <SHORT-NAME>ECMCoolngFanPWMReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECMCoolngFanPWMReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b3026fe00">
                  <SHORT-NAME>FuelCsump</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFuelCsump</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b3027bb00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtCrkAbotdRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b3027a000">
                  <SHORT-NAME>VehRfulSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehRfulSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b30276a00">
                  <SHORT-NAME>ECMCoolngFanPWMReqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECMCoolngFanPWMReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b30271900">
                  <SHORT-NAME>AccelAbsPosOBD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelAbsPosOBD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b30273400">
                  <SHORT-NAME>EnCalcLdValOBD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCalcLdValOBD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b34344bXOa505a3f19f25843c4b34344a00">
              <SHORT-NAME>ECM_25ms_PDU36</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_25ms_PDU36/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.025</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34345d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34348c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3434c200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircnF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34357f00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrRngInhSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34356400">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrMinVolReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3434f800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34359a00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrWrnngDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3434a700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34352e00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCustSetngDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3434dd00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvlnToqStabSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3435eb00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3435d000">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClStsV_ICE</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34354900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEnASSOvrd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34351300">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3435b500">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClSts_ICE</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34360600">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34362100">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34363c00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34365700">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34367200">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34368d00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3436a800">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3436c300">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b3436de00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34344bxOa505a3f19f25843c4b34347900">
                  <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_25ms_Group36</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b305c24XOa505a3f19f25843c4b305c2300">
              <SHORT-NAME>ECM_500ms_PDU14</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_500ms_PDU14/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.5</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305c8100">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305c9c00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305daa00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrClThrmlProtnNotfn_ECM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d7400">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d8f00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305cd200">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305c3600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsOBD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d2300">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305dc500">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d5900">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d3e00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdMsk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305cb700">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305d0800">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnWarmUpCycAch</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305ced00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305c6600">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305c24xOa505a3f19f25843c4b305c5200">
                  <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_500ms_group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b342a7eXOa505a3f19f25843c4b342a7d00">
              <SHORT-NAME>ECM_ZONE_020ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/ECM_020ms_PDU03_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/ECM_020ms_PDU03_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnASSFrngDet</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnASSFuelReqdOn</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnASSSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnASSStallDet</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnAutoSpNotProb</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnToqActuExtdRng</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnToqActuExtdRngV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnToqDrvrReqdExtdRng</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnToqDrvrReqdExtdRngV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/EnToqRducnFlrSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/PropSysA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_020ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342bb200">
                  <SHORT-NAME>ECM_020ms_PDU03_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342bcd00">
                  <SHORT-NAME>ECM_020ms_PDU03_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b2b00">
                  <SHORT-NAME>EnToqActuExtdRngV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b7c00">
                  <SHORT-NAME>EnToqRducnFlrSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqRducnFlrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b4600">
                  <SHORT-NAME>EnToqDrvrReqdExtdRng</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b1000">
                  <SHORT-NAME>EnToqActuExtdRng</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b9700">
                  <SHORT-NAME>PropSysA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPropSysA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342af500">
                  <SHORT-NAME>EnAutoSpNotProb</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnAutoSpNotProb</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342ada00">
                  <SHORT-NAME>EnASSStallDet</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSStallDet</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342be800">
                  <SHORT-NAME>EnASSSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342abf00">
                  <SHORT-NAME>EnASSFuelReqdOn</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFuelReqdOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342a9000">
                  <SHORT-NAME>EnASSFrngDet</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFrngDet</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342b6100">
                  <SHORT-NAME>EnToqDrvrReqdExtdRngV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342c0300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342c1e00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342a7exOa505a3f19f25843c4b342aac00">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_ZONE_020ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3428e4XOa505a3f19f25843c4b3428e300">
              <SHORT-NAME>ECM_ZONE_050ms_PDU09</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_ZONE_050ms_PDU09/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b3429e200">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b3429fd00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b3428f600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECODrvngSpdRutA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34292500">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngAIO</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34294000">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsGearShftIndSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34297600">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b3429ac00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b342a1800">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b3429c700">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34299100">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34295b00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsRcmndFwdGear</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b342a3300">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b342a4e00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3428e4xOa505a3f19f25843c4b34291200">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_ZONE_050ms_Group09</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2efcdaXOa505a3f19f25843c4b2efcd900">
              <SHORT-NAME>EPS_010ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>200707</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.005</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_010ms_PDU03/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd4800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd6300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd7e00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd9900">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESStsInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efcfd00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efe0500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efdb400">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCAngRespSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd2d00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorRespV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efdea00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCRespStsInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efe2000">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efdcf00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCCodrivingSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efe3b00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efcdaxOa505a3f19f25843c4b2efd1900">
                  <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_010ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2efe6bXOa505a3f19f25843c4b2efe6a00">
              <SHORT-NAME>EPS_10ms_PDU01</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>468229</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.005</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ADASStrgDlvrdToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ADASStrgDlvrdToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ActuPnonAng</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ActuPnonAngV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ActuRoadWhlAng</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ActuRoadWhlAngV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/CHLKAHptResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ChLKAAngReqResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/ChLKAToqReqResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/DrvrStrgDlvrdToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/DrvrStrgDlvrdToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSCoDrivingSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSCurntDrvMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSDrvngMdCtrlInh</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSFlrSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSPriyChnlFlrSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSToqValAldMax</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSToqValAldMaxV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSToqValAldMin</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPSToqValAldMinV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPS_10ms_Group01_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/EPS_10ms_Group01_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU01/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2efed800">
                  <SHORT-NAME>EPS_10ms_Group01_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2efef300">
                  <SHORT-NAME>EPS_10ms_Group01_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff2900">
                  <SHORT-NAME>ActuRoadWhlAngV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff5f00">
                  <SHORT-NAME>ADASStrgDlvrdToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f003700">
                  <SHORT-NAME>EPSDrvngMdCtrlInh</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSDrvngMdCtrlInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2effe600">
                  <SHORT-NAME>DrvrStrgDlvrdToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2efe8d00">
                  <SHORT-NAME>ActuPnonAng</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff0e00">
                  <SHORT-NAME>ActuRoadWhlAng</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f00f400">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgCustSetngDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f006d00">
                  <SHORT-NAME>EPSPriyChnlFlrSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSPriyChnlFlrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f005200">
                  <SHORT-NAME>EPSFlrSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSFlrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f001c00">
                  <SHORT-NAME>EPSCurntDrvMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCurntDrvMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2efebd00">
                  <SHORT-NAME>ActuPnonAngV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f00a300">
                  <SHORT-NAME>EPSToqValAldMaxV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMaxV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f016000">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f012a00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f017b00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff7a00">
                  <SHORT-NAME>ChLKAAngReqResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAAngReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f019600">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f00d900">
                  <SHORT-NAME>EPSToqValAldMinV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMinV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>68</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff9500">
                  <SHORT-NAME>CHLKAHptResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICHLKAHptResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f01b100">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2eff4400">
                  <SHORT-NAME>ADASStrgDlvrdToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>82</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f01cc00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2effb000">
                  <SHORT-NAME>ChLKAToqReqResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAToqReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f008800">
                  <SHORT-NAME>EPSToqValAldMax</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMax</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>98</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f000100">
                  <SHORT-NAME>EPSCoDrivingSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCoDrivingSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>100</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f01e700">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f00be00">
                  <SHORT-NAME>EPSToqValAldMin</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMin</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>114</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f020200">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f010f00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f021d00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2effcb00">
                  <SHORT-NAME>DrvrStrgDlvrdToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f023800">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>163</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f025300">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>175</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2f014500">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2efe6bxOa505a3f19f25843c4b2efea900">
                  <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f0441XOa505a3f19f25843c4b2f044000">
              <SHORT-NAME>EPS_10ms_PDU02</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>468230</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.005</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU02/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f04ae00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f04c900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f056b00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f051a00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqRespInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f04ff00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespStsInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f058600">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f053500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAvlLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f04e400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f049300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f05a100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f055000">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltCtrlChannel</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f046300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0441xOa505a3f19f25843c4b2f047f00">
                  <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f0887XOa505a3f19f25843c4b2f088600">
              <SHORT-NAME>EPS_10ms_PDU05</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>468244</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.005</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_10ms_PDU05/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f08f400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f090f00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f094500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrFlt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f099600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f097b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrMultCapb</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f096000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrInid</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f08a900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f08d900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngGrd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f09b100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f092a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrCalSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f09cc00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f09e700">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0887xOa505a3f19f25843c4b2f08c500">
                  <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group05</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33cbc6XOa505a3f19f25843c4b33cbc500">
              <SHORT-NAME>EPS_20ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_20ms_PDU03/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cca900">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33ccc400">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc8e00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPASts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc7300">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPAInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cbec00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc0700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc2200">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc3d00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cc5800">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33cbc6xOa505a3f19f25843c4b33cbd800">
                  <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_20ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f0401XOa505a3f19f25843c4b2f040000">
              <SHORT-NAME>EPS_CHCANFD_CT_Tx</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/EPS_CHCANFD_CT_Tx/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0401xOa505a3f19f25843c4b2f041300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCTTX</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2fe10bXOa505a3f19f25843c4b2fe10a00">
              <SHORT-NAME>ESS_100ms_PDU19</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>147460</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU19/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe12d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSEmsnRltdMalfA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>4</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe1eb00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOdoFctV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>5</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe14900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSCdstCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe1d000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOdoFct</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe20600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSStdAvlblEnrg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe16400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSChrgTrgtStdAvlblEnrg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe19a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSDisTrgtStdAvlblEnrg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe22100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSStdAvlblEnrgV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe17f00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSChrgTrgtStdAvlblEnrgV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe10bxOa505a3f19f25843c4b2fe1b500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSDisTrgtStdAvlblEnrgV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3366e1XOa505a3f19f25843c4b3366e000">
              <SHORT-NAME>ESS_100ms_PDU25</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>65796</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU25/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33678300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33679e00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b3367b900">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33674d00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSPosPtIsltnRstc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33676800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSPosPtIsltnRstcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33673200">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSNegPtIsltnRstcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33670300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSNegPtIsltnRstc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b3367d400">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b3367ef00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33680a00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3366e1xOa505a3f19f25843c4b33671f00">
                  <SHORT-NAME>ESS_100ms_Group25</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IESS_100ms_Group25</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2fe251XOa505a3f19f25843c4b2fe25000">
              <SHORT-NAME>ESS_100ms_PDU28</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>65794</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/BMSPackSOH</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/HVBatShutOff</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU28/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe2c500">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSStaOfHealthResi</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe2aa00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSStaOfHealthCapct</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe2fb00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOnbdChrgSpRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe28f00">
                  <SHORT-NAME>BMSPackSOH</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSPackSOH</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe27300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSFltLamp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fe251xOa505a3f19f25843c4b2fe2e000">
                  <SHORT-NAME>HVBatShutOff</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVBatShutOff</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2ff7efXOa505a3f19f25843c4b2ff7ee00">
              <SHORT-NAME>ESS_100ms_PDU54</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>74579</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU54/HVBatSOCHiRes</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU54/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU54/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU54/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2ff7efxOa505a3f19f25843c4b2ff86300">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVBatSOCHiResV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2ff7efxOa505a3f19f25843c4b2ff81100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVBatSOCMin</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2ff7efxOa505a3f19f25843c4b2ff84800">
                  <SHORT-NAME>HVBatSOCHiRes</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVBatSOCHiRes</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2ff7efxOa505a3f19f25843c4b2ff82d00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVBatSOCTrgtHiRes</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2fdcaeXOa505a3f19f25843c4b2fdcad00">
              <SHORT-NAME>ESS_100ms_PDU58</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>74584</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/BMSOfbdChrgrSktVol</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/BMSOfbdChrgrSktVolV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/BMSOffBdChrgrPlugOn</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/BMSOffBdChrgrPlugOnV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/ESS_100ms_Group58_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/ESS_100ms_Group58_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ESS_100ms_PDU58/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdce500">
                  <SHORT-NAME>ESS_100ms_Group58_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd0000">
                  <SHORT-NAME>ESS_100ms_Group58_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd3600">
                  <SHORT-NAME>BMSOfbdChrgrSktVolV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVolV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd8700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd5100">
                  <SHORT-NAME>BMSOffBdChrgrPlugOn</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdda200">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fddbd00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd1b00">
                  <SHORT-NAME>BMSOfbdChrgrSktVol</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fddf300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdd6c00">
                  <SHORT-NAME>BMSOffBdChrgrPlugOnV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOnV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fddd800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fde0e00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fde2900">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2fdcaexOa505a3f19f25843c4b2fdcd000">
                  <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IESS_100ms_Group58</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3107cdXOa505a3f19f25843c4b3107cc00">
              <SHORT-NAME>FDR_100ms_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/FDRSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FDR_100ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31081700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b3108e700">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b3108cc00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b3108b100">
                  <SHORT-NAME>FDRSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31089600">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b3107e000">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31087b00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b3107fc00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31083200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31086000">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3107cdxOa505a3f19f25843c4b31084d00">
                  <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFDR_100ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30ce2cXOa505a3f19f25843c4b30ce2b00">
              <SHORT-NAME>FVCM_100ms_PDU04</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCConfmSw</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCCurveSpdSw</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1Id</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1LatRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1LongtRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1LongtRltvSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1Risk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1SyncCtr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj1Typ</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2Id</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2LatRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2LongtRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2LongtRltvSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2Risk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2SyncCtr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj2Typ</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3Id</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3LatRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3LongtRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3LongtRltvSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3Risk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3SyncCtr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ACCDetObj3Typ</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/ELKWarning</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU04/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30ceab00">
                  <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LatRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cefc00">
                  <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Risk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf8300">
                  <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LatRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cfd400">
                  <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Risk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d05b00">
                  <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LatRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d0ac00">
                  <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Risk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cec600">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LongtRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cee100">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LongtRltvSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf9e00">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LongtRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cfb900">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LongtRltvSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d07600">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LongtRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d09100">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LongtRltvSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>123</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30ce3e00">
                  <SHORT-NAME>ACCConfmSw</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCConfmSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>137</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30ce7500">
                  <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30ce5a00">
                  <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCCurveSpdSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>145</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30ce9000">
                  <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Id</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf6800">
                  <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Id</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>153</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf4d00">
                  <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d02500">
                  <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>163</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d04000">
                  <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Id</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d0fd00">
                  <SHORT-NAME>ELKWarning</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKWarning</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cfef00">
                  <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2SyncCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>195</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf1700">
                  <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1SyncCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>199</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d0c700">
                  <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3SyncCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>207</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d00a00">
                  <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Typ</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>217</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30cf3200">
                  <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Typ</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>230</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxN200000119f4464397e2ded800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDrvrTkovReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>256</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30ce2cxOa505a3f19f25843c4b30d0e200">
                  <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Typ</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>506</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30dc52XOa505a3f19f25843c4b30dc5100">
              <SHORT-NAME>FVCM_100ms_PDU05</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_C0</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_C1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_C2</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_C3</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_ID</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_MarkerColor</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_MarkerType</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_Part0_SyncFrameIndex</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_ViewRangeEnd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_ViewRangeStart</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane0_location</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_C0</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_C1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_C2</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_C3</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_ID</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_MarkerColor</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_MarkerType</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_Part0_SyncFrameIndex</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_ViewRangeEnd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_ViewRangeStart</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane1_location</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_C0</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_C1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_C2</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_C3</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_ID</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_MarkerColor</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_MarkerType</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_Part0_SyncFrameIndex</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_ViewRangeEnd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_ViewRangeStart</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane2_location</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_C0</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_C1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_C2</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_C3</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_ExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_ID</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_MarkerColor</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_MarkerType</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_Part0_SyncFrameIndex</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_ViewRangeEnd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_ViewRangeStart</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/Lane3_location</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/PilotSysMsg</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/SpdLmtOfstSetResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/TLRMdSwDspCmd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/TLRMsgReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/TLRSysSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/TLRWarning</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_100ms_PDU05/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e17600">
                  <SHORT-NAME>PilotSysMsg</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysMsg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dc6600">
                  <SHORT-NAME>Lane0_C0</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C0</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dc8100">
                  <SHORT-NAME>Lane0_C1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dc9c00">
                  <SHORT-NAME>Lane0_C2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dcb700">
                  <SHORT-NAME>Lane0_C3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30ddaa00">
                  <SHORT-NAME>Lane1_C0</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C0</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30ddc500">
                  <SHORT-NAME>Lane1_C1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dde000">
                  <SHORT-NAME>Lane1_C2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30ddfb00">
                  <SHORT-NAME>Lane1_C3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30deee00">
                  <SHORT-NAME>Lane2_C0</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C0</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df0900">
                  <SHORT-NAME>Lane2_C1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>123</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df2400">
                  <SHORT-NAME>Lane2_C2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df3f00">
                  <SHORT-NAME>Lane2_C3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>147</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e03200">
                  <SHORT-NAME>Lane3_C0</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C0</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e04d00">
                  <SHORT-NAME>Lane3_C1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>171</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e06800">
                  <SHORT-NAME>Lane3_C2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e08300">
                  <SHORT-NAME>Lane3_C3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>195</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd8f00">
                  <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ViewRangeStart</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>215</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30ded300">
                  <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ViewRangeStart</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>223</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e01700">
                  <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ViewRangeStart</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>231</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e15b00">
                  <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ViewRangeStart</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>239</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd7400">
                  <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ViewRangeEnd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>247</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30deb800">
                  <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ViewRangeEnd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>248</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dcd200">
                  <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>254</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dffc00">
                  <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ViewRangeEnd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>271</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e14000">
                  <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ViewRangeEnd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>272</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de1600">
                  <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>278</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd5900">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_Part0_SyncFrameIndex</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>291</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dced00">
                  <SHORT-NAME>Lane0_ID</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>295</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de9d00">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_Part0_SyncFrameIndex</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>299</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de3100">
                  <SHORT-NAME>Lane1_ID</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>303</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dfe100">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_Part0_SyncFrameIndex</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>307</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df7500">
                  <SHORT-NAME>Lane2_ID</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>311</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e12500">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_Part0_SyncFrameIndex</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>315</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e0b900">
                  <SHORT-NAME>Lane3_ID</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>319</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e1c700">
                  <SHORT-NAME>TLRMsgReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITLRMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>321</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd2300">
                  <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_MarkerColor</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>324</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd0800">
                  <SHORT-NAME>Lane0_location</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_location</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>327</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e1e200">
                  <SHORT-NAME>TLRSysSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITLRSysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>329</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de4c00">
                  <SHORT-NAME>Lane1_location</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_location</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>332</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dd3e00">
                  <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_MarkerType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>335</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de8200">
                  <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_MarkerType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>340</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30de6700">
                  <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_MarkerColor</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>343</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df5a00">
                  <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>351</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dfab00">
                  <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_MarkerColor</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>356</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30df9000">
                  <SHORT-NAME>Lane2_location</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_location</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>359</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e0d400">
                  <SHORT-NAME>Lane3_location</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_location</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>364</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30dfc600">
                  <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_MarkerType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>367</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e09e00">
                  <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>375</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e10a00">
                  <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_MarkerType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>380</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e0ef00">
                  <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_MarkerColor</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>383</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e1fd00">
                  <SHORT-NAME>TLRWarning</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITLRWarning</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>388</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e1ac00">
                  <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITLRMdSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>391</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e19100">
                  <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>399</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e23300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjHdngAng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>495</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30dc52xOa505a3f19f25843c4b30e21800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmdCnfm</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>503</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30cc90XOa505a3f19f25843c4b30cc8f00">
              <SHORT-NAME>FVCM_10ms_PDU01</SHORT-NAME>
              <LENGTH>12</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/FVCM_10ms_Group01_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/FVCM_10ms_Group01_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/LKAReqAng</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/LKAReqAngSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/LKAReqToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/LKAReqToqSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_10ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30ccd300">
                  <SHORT-NAME>FVCM_10ms_Group01_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30ccee00">
                  <SHORT-NAME>FVCM_10ms_Group01_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd2400">
                  <SHORT-NAME>LKAReqToqSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToqSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd3f00">
                  <SHORT-NAME>LKAReqAngSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAngSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30ccb800">
                  <SHORT-NAME>LKAReqAng</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd0900">
                  <SHORT-NAME>LKAReqToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd5a00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd7500">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cd9000">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cdab00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cdc600">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cde100">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cdfc00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30cc90xOa505a3f19f25843c4b30cca300">
                  <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFVCM_10ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33b612XOa505a3f19f25843c4b33b61100">
              <SHORT-NAME>FVCM_20ms_PDU02</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/FVCM_20ms_PDU02/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b71100">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b72c00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b8db00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b6f600">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b65400">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDrvrSelTrgtSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b66f00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoNotfr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b8f500">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b63900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjDistLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b8c100">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSysSts_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b6db00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b6c000">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b6a500">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSeldTrgtDistLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b90f00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b74700">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b77d00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnDircnDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>76</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b92900">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b7b300">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b7ce00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b79800">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnVelDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b76200">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnStaV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>88</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b80400">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAAudReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b7e900">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>92</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b81f00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKADspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b94300">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>98</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b87000">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKADrvrTkovReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b85500">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>101</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b83a00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b88b00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>105</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b95d00">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b97700">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b8a600">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnStaV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>114</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b68a00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b99100">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b612xOa505a3f19f25843c4b33b62600">
                  <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFVCM_20ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU-GROUP UUID="68323ddd1c1a37beb33a7a13ce794af7">
              <SHORT-NAME>IPD_BKPCANFD_Rx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/BCM_100ms_PDU41</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/DKMM_Sporadic_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FDR_100ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU08</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU18</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU21</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_20ms_PDU32</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_Sporadic_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU49</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU55</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU58</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU59</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU60</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU61</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU62</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU63</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU64</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU65</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU66</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU34</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU35</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU40</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU56</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU57</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_1000ms_PDU50</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU17</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU25</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU257</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU27</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU31</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU35</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU47</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU48</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU80</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU50</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU79</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU00</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_250ms_PDU52</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU11</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU158</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU55</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOCComKeyReq_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOC_SyncMsg</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_Sporadic_PDU138</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU146</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU147</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU159</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU221</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU82</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_500ms_PDU229</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_Sporadic_PDU67</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_ZONE_100ms_PDU00</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU14</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU15</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU16</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU22</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU30</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU32</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_20ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU08</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU24</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU34</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU58</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_100ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_20ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHRDA_50ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU10</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU15</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU20</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU27</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_ICBVC_50ms_PDU14</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU37</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TPMS_400ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/Teter_ECM_10ms_PDU20</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU76</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU77</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="07a2e4c7b97f3591a3cb6467f51b2b2e">
              <SHORT-NAME>IPD_BKPCANFD_Tx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/DIAG_DTCInfo_ICBAD</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_100ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_100ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_20ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU25</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU27</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU29</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU31</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU34</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU36</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU37</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU38</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU39</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU44</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU08</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU09</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU48</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_50ms_PDU17</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCComKeyResp_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCLog_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU124</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU127</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU128</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU130</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU16</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU35</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU50</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU58</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU61</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_10ms_PDU59</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU60</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU14</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_BKBCANFD_EvtInfo</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU35</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="3eb88a91a0ca3d6c964a6682a1c674e3">
              <SHORT-NAME>IPD_CHCANFD_Rx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_010ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_10ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_10ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_20ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_CHCANFD_CT_Tx</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_100ms_PDU15</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_10ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_10ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU08</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU09</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU10</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU11</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU12</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU26</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_ZONE_20ms_PDU08</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU64</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="511ace65571f3775a390b44a473bca86">
              <SHORT-NAME>IPD_CHCANFD_Tx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_100ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU09</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU16</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU48</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_50ms_PDU21</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_Sporadic_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_10ms_PDU20</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU35</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU60</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU62</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="6f9fc0338ac439db835a1d0aa205c2a5">
              <SHORT-NAME>IPD_PTCANFD_Rx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU04</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU11</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_010ms_PDU00</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_100ms_PDU11</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_25ms_PDU36</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_500ms_PDU14</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_020ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_050ms_PDU09</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU58</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU19</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_500ms_PDU67</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU256</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PEU_10ms_PDU25</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICM_100ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU23</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_20ms_PDU11</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_1000ms_PDU67</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU10</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU22</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU23</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU24</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU90</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU06</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU25</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_020ms_PDU18</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU20</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TC_IMCU_50ms_PDU28</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="82c5c88f832b3e98ba6f0fd1664bf705">
              <SHORT-NAME>IPD_PTCANFD_Tx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_20ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU29</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU36</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU05</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU15</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU64</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU67</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="bd8acf11b5c13f0897e67fe134d63ad9">
              <SHORT-NAME>IPD_SFCANFD_Rx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU18</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU49</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU41</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_100ms_PDU03</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU02</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TDM_200ms_PDU01</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU-GROUP UUID="59f9bce38e6b3368a93e84e76ecdf050">
              <SHORT-NAME>IPD_SFCANFD_Tx</SHORT-NAME>
              <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
              <I-SIGNAL-I-PDUS>
                <I-SIGNAL-I-PDU-REF-CONDITIONAL>
                  <I-SIGNAL-I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU27</I-SIGNAL-I-PDU-REF>
                </I-SIGNAL-I-PDU-REF-CONDITIONAL>
              </I-SIGNAL-I-PDUS>
            </I-SIGNAL-I-PDU-GROUP>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32b357XOa505a3f19f25843c4b32b35600">
              <SHORT-NAME>IAM_100ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>209158</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/CANprotocolinternalversion</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/DiffDataLinkBroken</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/GNSSAntennasBroken</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/GNSSAntennasInfo</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/Veleastsigma</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU03/Velnorthsigma</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b37900">
                  <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICANprotocolinternalversion</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b39500">
                  <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDiffDataLinkBroken</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b3b000">
                  <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSAntennasBroken</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b3cb00">
                  <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSAntennasInfo</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b40100">
                  <SHORT-NAME>Velnorthsigma</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVelnorthsigma</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b357xOa505a3f19f25843c4b32b3e600">
                  <SHORT-NAME>Veleastsigma</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVeleastsigma</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33192cXOa505a3f19f25843c4b33192b00">
              <SHORT-NAME>IAM_100ms_PDU04</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>209176</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU04/TrfcForbidDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU04/TrfcInfoSignDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IAM_100ms_PDU04/X1</I-SIGNAL-IN-I-PDU-REF>
