                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD6/EvtPotclSigIPD6</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EvtPotclSigIPD6</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD6</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaa1b00">
                  <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD7/EvtPotclSigIPD7</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EvtPotclSigIPD7</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD7</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaa3e00">
                  <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD8/EvtPotclSigIPD8</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EvtPotclSigIPD8</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD8</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb96a100">
                  <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTBSysFltSts/FCTBSysFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTBSysFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6fb200">
                  <SHORT-NAME>FCTSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSwSts/FCTSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTSwSts</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6fd500">
                  <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysFltSts/FCTSysFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTSysFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb393b00">
                  <SHORT-NAME>FCWDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWDspCmd/FCWDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWDspCmd</SHORT-LABEL>
                          <VALUE>0x2</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb395e00">
                  <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSnstvtLvl/FCWSnstvtLvl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWSnstvtLvl</SHORT-LABEL>
                          <VALUE>0x2</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb9c83400">
                  <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSysFltSts/FCWSysFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWSysFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb9c99200">
                  <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWrnngSts/FCWrnngSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWrnngSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWrnngSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6bde00">
                  <SHORT-NAME>FLObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLObsRng/FLObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb754d00">
                  <SHORT-NAME>FLSObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSObsRng/FLSObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLSObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb743500">
                  <SHORT-NAME>FLSUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSUSSSts/FLSUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLSUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6da500">
                  <SHORT-NAME>FLSideObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSideObsRng/FLSideObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLSideObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb73a900">
                  <SHORT-NAME>FLUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLUSSSts/FLUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb73cc00">
                  <SHORT-NAME>FMLUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FMLUSSSts/FMLUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FMLUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb73ef00">
                  <SHORT-NAME>FMRUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FMRUSSSts/FMRUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FMRUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6c0100">
                  <SHORT-NAME>FRObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRObsRng/FRObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb757000">
                  <SHORT-NAME>FRSObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSObsRng/FRSObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRSObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb741200">
                  <SHORT-NAME>FRSUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSUSSSts/FRSUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRSUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6dc800">
                  <SHORT-NAME>FRSideObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSideObsRng/FRSideObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRSideObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb745800">
                  <SHORT-NAME>FRUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRUSSSts/FRUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb344f00">
                  <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FVCM_10ms_Group01/FVCM_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FVCM_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAReqAng</SHORT-LABEL>
                              <VALUE>0x7F58</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAReqAngSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAReqToq</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAReqToqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_10ms_Group01_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba5a600">
                  <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FVCM_20ms_Group02/FVCM_20ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FVCM_20ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCDetObjDistLvl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCDrvrSelTrgtSpd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCGoNotfr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCMsgReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCSeldTrgtDistLvl</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCTJAMdSwDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCTotWhlToqReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCTotWhlToqReqVal</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HandOffStrgWhlDetnSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HandOffStrgWhlDetnStaV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ILCActvnDircnDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ILCActvnVelDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ILCSwDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ILCSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWAdoWrnngDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKAAudReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKADspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKAHptWrnngDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWSnstvtLvl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKADrvrTkovReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeOffRoadDetnSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeOffRoadDetnStaV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ELKSysSts_IPD</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved4</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved6</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved7</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FVCM_20ms_Group02_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_20ms_Group02</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbad8600">
                  <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCamrHeatCtrl/FrtCamrHeatCtrl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtCamrHeatCtrl</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatCtrl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6a5d00">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCarGoNotfrDspCmd/FrtCarGoNotfrDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtCarGoNotfrDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6c2400">
                  <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtMidLObsRng/FrtMidLObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtMidLObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6c4700">
                  <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtMidRObsRng/FrtMidRObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtMidRObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6cf600">
                  <SHORT-NAME>FrtObsDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtObsDist/FrtObsDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtObsDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6d5f00">
                  <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtPDCAudWrnng/FrtPDCAudWrnng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtPDCAudWrnng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbae6300">
                  <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HORWarningEvtSts/HORWarningEvtSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HORWarningEvtSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HORWarningEvtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb768800">
                  <SHORT-NAME>HPPFnSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPFnSts/HPPFnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HPPFnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPFnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb76f100">
                  <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPInBmtSts/HPPInBmtSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HPPInBmtSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPInBmtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb76ab00">
                  <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPMapBuildSts/HPPMapBuildSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HPPMapBuildSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPMapBuildSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb76ce00">
                  <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPOnRoutSts/HPPOnRoutSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HPPOnRoutSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPOnRoutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb94fd00">
                  <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCOvTSuppresCmd/IACCOvTSuppresCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IACCOvTSuppresCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb94da00">
                  <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreMsgReq/IACCPreMsgReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IACCPreMsgReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb94b700">
                  <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreSpdLimtCmd/IACCPreSpdLimtCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IACCPreSpdLimtCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbab1a00">
                  <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group25/ICBAD_100ms_Group25</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_100ms_Group25</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MemPkngSlntPtrlEnbSwResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MemPkngSwResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEBSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved31</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved39</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved47</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved79</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved87</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved103</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved111</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved127</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved135</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved143</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved151</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved159</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved167</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved175</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved183</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved191</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group25_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group25</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9cad00">
                  <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group37/ICBAD_100ms_Group37</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_100ms_Group37</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoLaneChngMsgReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoLaneChngSetResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoLaneChngSwDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DILampsCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HzrdLampsCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved3</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved4</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved5</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved6</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_100ms_Group37_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group37</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb342c00">
                  <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_10ms_Group01/ICBAD_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSToqAppdCoefnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PltEPSRdWhlAngReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PltEPSRdWhlAngReqStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved7</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved14</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved15</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved16</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved17</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved18</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved19</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved20</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved21</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved22</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_10ms_Group01_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f5e2186131e12700">
                  <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group05/ICBAD_20ms_Group05</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group05</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APARevrDrgReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAToqReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAVCUReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APACrpSpdReqVal_IPD</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APATotWhlToqReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved14</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group05_Reserved15</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group05</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba0d300">
                  <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group07/ICBAD_20ms_Group07</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group07</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group07_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group07_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCAccReqSts_CH</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCAccReqVal</SHORT-LABEL>
                              <VALUE>0x6B1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCGoReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCSdslReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysEmgcBrkReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysEmgcBrkReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AIPkgAPASCSAcclReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAEPBOPReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAEPBOPReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSAcclReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysFlrStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysMdReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysMdReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysSCSDrvOffReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysSCSDrvOffReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysSCSSdslReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysSCSSdslReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group07_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group07</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9cf700">
                  <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group09/ICBAD_20ms_Group09</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group09</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NSABacSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NSADisFucSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NSAForSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NSAReqAVMDis</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group09_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group09</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8f5300">
                  <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group12/ICBAD_20ms_Group12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group12</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved2</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group12_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group12</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb25d8d00">
                  <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group13/ICBAD_20ms_Group13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group13</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APACmdEPSSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCUReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCUReqStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAShifterPosReqd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAShifterPosReqdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APATrgtEPSStrgWhlAng</SHORT-LABEL>
                              <VALUE>0x8000</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_Reserved4</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group13_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5d0800">
                  <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group15/ICBAD_20ms_Group15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group15</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysStsPT</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCOtptShaftTotToqReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCOtptShaftTotToqReqVal</SHORT-LABEL>
                              <VALUE>0x6A0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCDclReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved3</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group15_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group15</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba11d00">
                  <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group46/ICBAD_20ms_Group46</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group46</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBBrkJerkLvlReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqVal</SHORT-LABEL>
                              <VALUE>0x7F</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBHydBrkAstLvlReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBPrflReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBSysSts</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group46_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group46_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group46_Reserved1</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group46_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group46</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8e7900">
                  <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group48/ICBAD_20ms_Group48</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_20ms_Group48</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKAVbnLvlReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKALVsulznReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWLKARVsulznReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDWSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved4</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_20ms_Group48_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group48</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb347200">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_ZONE_10ms_Group20</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAToqReqValMax</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKAToqReqValMin</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved4</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved5</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_10ms_Group20_Reserved6</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_10ms_Group20</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8e9c00">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBAD_ZONE_20ms_Group13</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKASysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LKASysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TJAICASysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TJAICASysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCToqReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCToqReqVal</SHORT-LABEL>
                              <VALUE>0x6A0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved2</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved3</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved4</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBAD_ZONE_20ms_Group13_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8ee600">
                  <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAVCamrHeatReq/IPDAVCamrHeatReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDAVCamrHeatReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAVCamrHeatReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb60a600">
                  <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAlgFlag/IPDAlgFlag</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDAlgFlag</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAlgFlag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5b3900">
                  <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAurixTemp/IPDAurixTemp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDAurixTemp</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAurixTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5f8e00">
                  <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDComKeyEnbResp/IPDComKeyEnbResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDComKeyEnbResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDComKeyEnbResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5fb100">
                  <SHORT-NAME>IPDDataId</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDDataId/IPDDataId</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDDataId</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDDataId</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb603d00">
                  <SHORT-NAME>IPDErrorCount</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDErrorCount/IPDErrorCount</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDErrorCount</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDErrorCount</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5fd400">
                  <SHORT-NAME>IPDFailedReason</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDFailedReason/IPDFailedReason</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDFailedReason</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDFailedReason</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5eb000">
                  <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDIdentityResp/IPDIdentityResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDIdentityResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDIdentityResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb608300">
                  <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDKeyStatus/IPDKeyStatus</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDKeyStatus</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDKeyStatus</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ab600">
                  <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDMCUTemp/IPDMCUTemp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDMCUTemp</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDMCUTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5b7f00">
                  <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPCBTemp1/IPDPCBTemp1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDPCBTemp1</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5ba200">
                  <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPCBTemp2/IPDPCBTemp2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDPCBTemp2</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5bc500">
                  <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPMICTemp/IPDPMICTemp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDPMICTemp</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPMICTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5ff700">
                  <SHORT-NAME>IPDResetCnt</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDResetCnt/IPDResetCnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDResetCnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDResetCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5b5c00">
                  <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDSOCTemp/IPDSOCTemp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDSOCTemp</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDSOCTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5be800">
                  <SHORT-NAME>IPDStsResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDStsResp/IPDStsResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDStsResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDStsResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5c0b00">
                  <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDThermalWrnngLvl/IPDThermalWrnngLvl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDThermalWrnngLvl</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDThermalWrnngLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb601a00">
                  <SHORT-NAME>IPDTripCnt</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripCnt/IPDTripCnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDTripCnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5f4500">
                  <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripCntResetResp/IPDTripCntResetResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDTripCntResetResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCntResetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb606000">
                  <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripNvmTag/IPDTripNvmTag</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDTripNvmTag</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripNvmTag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5c2e00">
                  <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltFlwReq/IPDWtrClntInltFlwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDWtrClntInltFlwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltFlwReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ad900">
                  <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltReqFlg/IPDWtrClntInltReqFlg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDWtrClntInltReqFlg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltReqFlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5c5100">
                  <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltTimeReq/IPDWtrClntInltTimeReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDWtrClntInltTimeReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltTimeReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9c4000">
                  <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group43/IPD_20ms_Group43</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_20ms_Group43</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCAccReqToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCSysFltSts_SCS</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtCarGoNotfr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_Reserved2</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group43_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group43</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9c8a00">
                  <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group60/IPD_20ms_Group60</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_20ms_Group60</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ALCSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ALCSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSToqReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAVehCrdnatAzmth</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAVehCrdnatPosX</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAVehCrdnatPosY</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoLaneChngLLaneSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoLaneChngRLaneSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSDirInd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSDrvrTkovReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSSysSts</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NOPSysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>NOPSysSts_ZPD</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Parkngslottype</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PilotTkovMsgReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PrkgDstCtrlSwResp</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved4</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved6</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved7</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group60_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group60</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb90f400">
                  <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group64/IPD_20ms_Group64</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_20ms_Group64</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAEnToqReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAEnToqReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSBrkFn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSBrkFnMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSDrvrReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSParkngPrflReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSParkngTrgtDist</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSParkngVelMax</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APASCSReqSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group64_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group64</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb25a00">
                  <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group67/IPD_20ms_Group67</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_20ms_Group67</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ADS_SpdAstSysTrgtSpd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ADS_SpdAstSysTrgtSpdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved31</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved39</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved47</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_20ms_Group67_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group67</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8fe700">
                  <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_50ms_Group14/IPD_50ms_Group14</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_50ms_Group14</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LADSInfoDispReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LADSInfoDispReqToICM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LADSProgressBar</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDWLSFObsRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDWLSRObsRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDWRSFObsRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDWRSRObsRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved7</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group14_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group14</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9e0400">
                  <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_50ms_Group49/IPD_50ms_Group49</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_50ms_Group49</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>KeepPwrRsnIPD</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysPwrMdCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>APAEnRunReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LADSAFnInd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved1</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved2</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved4</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IPD_50ms_Group49_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group49</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb43e500">
                  <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_BKPCANFD/IPD_NKI_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NKI_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb46e700">
                  <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_CHCANFD/IPD_NKI_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NKI_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb456600">
                  <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_PTCANFD/IPD_NKI_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NKI_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8a8800">
                  <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_SFCANFD/IPD_NKI_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NKI_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb472d00">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_BKPCANFD/IPD_NM_BSMtoRMS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb45ac00">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_CHCANFD/IPD_NM_BSMtoRMS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_BSMtoRMS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb442b00">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_PTCANFD/IPD_NM_BSMtoRMS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_BSMtoRMS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8bbc00">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_SFCANFD/IPD_NM_BSMtoRMS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_BSMtoRMS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb475000">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_BKPCANFD/IPD_NM_NOSSta_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOSSta_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb45cf00">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_CHCANFD/IPD_NM_NOSSta_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOSSta_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb444e00">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_PTCANFD/IPD_NM_NOSSta_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOSSta_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8bdf00">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_SFCANFD/IPD_NM_NOSSta_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOSSta_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb42f000">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_BKPCANFD/IPD_NM_NOStoRMS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOStoRMS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb45f200">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_CHCANFD/IPD_NM_NOStoRMS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOStoRMS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb447100">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_PTCANFD/IPD_NM_NOStoRMS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOStoRMS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8c0200">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_SFCANFD/IPD_NM_NOStoRMS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_NOStoRMS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb431300">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_BKPCANFD/IPD_NM_PBSMtoRMS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb461500">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_CHCANFD/IPD_NM_PBSMtoRMS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb449400">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_PTCANFD/IPD_NM_PBSMtoRMS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8c2500">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_SFCANFD/IPD_NM_PBSMtoRMS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb433600">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_BKPCANFD/IPD_NM_RMSSta_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMSSta_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb463800">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_CHCANFD/IPD_NM_RMSSta_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMSSta_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb44b700">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_PTCANFD/IPD_NM_RMSSta_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMSSta_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8c4800">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_SFCANFD/IPD_NM_RMSSta_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMSSta_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb435900">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_BKPCANFD/IPD_NM_RMStoNOS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMStoNOS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb465b00">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_CHCANFD/IPD_NM_RMStoNOS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMStoNOS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb44da00">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_PTCANFD/IPD_NM_RMStoNOS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMStoNOS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8c6b00">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_SFCANFD/IPD_NM_RMStoNOS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RMStoNOS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb437c00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_BKPCANFD/IPD_NM_RSStoNOS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoNOS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb467e00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_CHCANFD/IPD_NM_RSStoNOS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoNOS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb44fd00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_PTCANFD/IPD_NM_RSStoNOS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoNOS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8c8e00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_SFCANFD/IPD_NM_RSStoNOS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoNOS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb439f00">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_BKPCANFD/IPD_NM_RSStoRMS_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoRMS_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb46a100">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_CHCANFD/IPD_NM_RSStoRMS_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoRMS_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb452000">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_PTCANFD/IPD_NM_RSStoRMS_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoRMS_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8cb100">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_SFCANFD/IPD_NM_RSStoRMS_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NM_RSStoRMS_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb43c200">
                  <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_BKPCANFD/IPD_NOI_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NOI_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb46c400">
                  <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_CHCANFD/IPD_NOI_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NOI_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb454300">
                  <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_PTCANFD/IPD_NOI_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NOI_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8cd400">
                  <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_SFCANFD/IPD_NOI_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NOI_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb440800">
                  <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_BKPCANFD/IPD_NWI_BKPCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NWI_BKPCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb470a00">
                  <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_CHCANFD/IPD_NWI_CHCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NWI_CHCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb458900">
                  <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_PTCANFD/IPD_NWI_PTCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NWI_PTCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8cf700">
                  <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_SFCANFD/IPD_NWI_SFCANFD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_NWI_SFCANFD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb477300">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_Sporadic_TimeSync_Group/IPD_Sporadic_TimeSync_Group</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_Sporadic_TimeSync_Group</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgType</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgCheckSum</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgSequenceCounter</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgTimeDomain</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgOVS</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgSGW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgreserved</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SyncMsgTime</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_Sporadic_TimeSync_Group</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb738600">
                  <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_VehLckCtrlReq/IPD_VehLckCtrlReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPD_VehLckCtrlReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_VehLckCtrlReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb782c00">
                  <SHORT-NAME>JAMsgReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/JAMsgReq/JAMsgReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>JAMsgReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/JAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6a8000">
                  <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LADSCurToEndPntDist/LADSCurToEndPntDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LADSCurToEndPntDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSCurToEndPntDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb771400">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LADSInfoDispReqToICM_HPP/LADSInfoDispReqToICM_HPP</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LADSInfoDispReqToICM_HPP</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSInfoDispReqToICM_HPP</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6f2600">
                  <SHORT-NAME>LCRInHMI</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRInHMI/LCRInHMI</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LCRInHMI</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRInHMI</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6f0300">
                  <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRSwDspCmd/LCRSwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LCRSwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8a4200">
                  <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWStsForEdr/LDWStsForEdr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LDWStsForEdr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6ff800">
                  <SHORT-NAME>LFCTWrnng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LFCTWrnng/LFCTWrnng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LFCTWrnng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb398100">
                  <SHORT-NAME>Lane0_C0</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C0/Lane0_C0</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_C0</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb39a400">
                  <SHORT-NAME>Lane0_C1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C1/Lane0_C1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_C1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb39c700">
                  <SHORT-NAME>Lane0_C2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C2/Lane0_C2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_C2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb39ea00">
                  <SHORT-NAME>Lane0_C3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C3/Lane0_C3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_C3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3a0d00">
                  <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ExistPrblty/Lane0_ExistPrblty</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_ExistPrblty</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3a3000">
                  <SHORT-NAME>Lane0_ID</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ID/Lane0_ID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_ID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3a5300">
                  <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_MarkerColor/Lane0_MarkerColor</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_MarkerColor</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3a7600">
                  <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_MarkerType/Lane0_MarkerType</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_MarkerType</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3a9900">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_Part0_SyncFrameIndex/Lane0_Part0_SyncFrameIndex</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_Part0_SyncFrameIndex</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3abc00">
                  <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ViewRangeEnd/Lane0_ViewRangeEnd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_ViewRangeEnd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3adf00">
                  <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ViewRangeStart/Lane0_ViewRangeStart</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_ViewRangeStart</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3b0200">
                  <SHORT-NAME>Lane0_location</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_location/Lane0_location</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane0_location</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3b2500">
                  <SHORT-NAME>Lane1_C0</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C0/Lane1_C0</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_C0</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3b4800">
                  <SHORT-NAME>Lane1_C1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C1/Lane1_C1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_C1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3b6b00">
                  <SHORT-NAME>Lane1_C2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C2/Lane1_C2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_C2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3b8e00">
                  <SHORT-NAME>Lane1_C3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C3/Lane1_C3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_C3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3bb100">
                  <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ExistPrblty/Lane1_ExistPrblty</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_ExistPrblty</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3bd400">
                  <SHORT-NAME>Lane1_ID</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ID/Lane1_ID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_ID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3bf700">
                  <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_MarkerColor/Lane1_MarkerColor</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_MarkerColor</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3c1a00">
                  <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_MarkerType/Lane1_MarkerType</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_MarkerType</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3c3d00">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_Part0_SyncFrameIndex/Lane1_Part0_SyncFrameIndex</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_Part0_SyncFrameIndex</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3c6000">
                  <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ViewRangeEnd/Lane1_ViewRangeEnd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_ViewRangeEnd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3c8300">
                  <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ViewRangeStart/Lane1_ViewRangeStart</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_ViewRangeStart</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3ca600">
                  <SHORT-NAME>Lane1_location</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_location/Lane1_location</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane1_location</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3cc900">
                  <SHORT-NAME>Lane2_C0</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C0/Lane2_C0</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_C0</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3cec00">
                  <SHORT-NAME>Lane2_C1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C1/Lane2_C1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_C1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3d0f00">
                  <SHORT-NAME>Lane2_C2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C2/Lane2_C2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_C2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3d3200">
                  <SHORT-NAME>Lane2_C3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C3/Lane2_C3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_C3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3d5500">
                  <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ExistPrblty/Lane2_ExistPrblty</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_ExistPrblty</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3d7800">
                  <SHORT-NAME>Lane2_ID</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ID/Lane2_ID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_ID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3d9b00">
                  <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_MarkerColor/Lane2_MarkerColor</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_MarkerColor</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3dbe00">
                  <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_MarkerType/Lane2_MarkerType</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_MarkerType</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3de100">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_Part0_SyncFrameIndex/Lane2_Part0_SyncFrameIndex</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_Part0_SyncFrameIndex</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3e0400">
                  <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ViewRangeEnd/Lane2_ViewRangeEnd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_ViewRangeEnd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3e2700">
                  <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ViewRangeStart/Lane2_ViewRangeStart</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_ViewRangeStart</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3e4a00">
                  <SHORT-NAME>Lane2_location</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_location/Lane2_location</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane2_location</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3e6d00">
                  <SHORT-NAME>Lane3_C0</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C0/Lane3_C0</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_C0</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3e9000">
                  <SHORT-NAME>Lane3_C1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C1/Lane3_C1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_C1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3eb300">
                  <SHORT-NAME>Lane3_C2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C2/Lane3_C2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_C2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3ed600">
                  <SHORT-NAME>Lane3_C3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C3/Lane3_C3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_C3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3ef900">
                  <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ExistPrblty/Lane3_ExistPrblty</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_ExistPrblty</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3f1c00">
                  <SHORT-NAME>Lane3_ID</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ID/Lane3_ID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_ID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3f3f00">
                  <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_MarkerColor/Lane3_MarkerColor</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_MarkerColor</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3f6200">
                  <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_MarkerType/Lane3_MarkerType</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_MarkerType</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3f8500">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_Part0_SyncFrameIndex/Lane3_Part0_SyncFrameIndex</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_Part0_SyncFrameIndex</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3fa800">
                  <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ViewRangeEnd/Lane3_ViewRangeEnd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_ViewRangeEnd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3fcb00">
                  <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ViewRangeStart/Lane3_ViewRangeStart</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_ViewRangeStart</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb3fee00">
                  <SHORT-NAME>Lane3_location</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_location/Lane3_location</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Lane3_location</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbadf700">
                  <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemParkngBtnRcnm/MemParkngBtnRcnm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MemParkngBtnRcnm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemParkngBtnRcnm</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6f6c00">
                  <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOACitySysMsg/NOACitySysMsg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOACitySysMsg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOACitySysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6e3100">
                  <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOADistDecMsg/NOADistDecMsg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOADistDecMsg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOADistDecMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6f8f00">
                  <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAETCSetDspCmd/NOAETCSetDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAETCSetDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6ebd00">
                  <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOALaneSetDspCmd/NOALaneSetDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOALaneSetDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6ee000">
                  <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAQukChgSwDspCmd/NOAQukChgSwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAQukChgSwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6e9a00">
                  <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAReportSetDspCmd/NOAReportSetDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAReportSetDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6f4900">
                  <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPCitySwDspCmd/NOPCitySwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOPCitySwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6e5400">
                  <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSwDspCmd/NOPSwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOPSwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6e7700">
                  <SHORT-NAME>NOPSysMsg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSysMsg/NOPSysMsg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOPSysMsg</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb72d700">
                  <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssSwResp/NarRoVslAssSwResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarRoVslAssSwResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb70a700">
                  <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarrowRoadBackwardSts/NarrowRoadBackwardSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarrowRoadBackwardSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadBackwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb70ca00">
                  <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarrowRoadForwardSts/NarrowRoadForwardSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarrowRoadForwardSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadForwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb70ed00">
                  <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstBtnSts/NarwSpcAstBtnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarwSpcAstBtnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstBtnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f8230bf8d4571400">
                  <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstSwSts/NarwSpcAstSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarwSpcAstSwSts</SHORT-LABEL>
                          <VALUE>0x2</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb401100">
                  <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSwDspCmd/NonDirectDMSSwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NonDirectDMSSwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb403400">
                  <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSysSts/NonDirectDMSSysSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NonDirectDMSSysSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb734000">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwDscmd/NrwroadBwdAssConfrmSwDscmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadBwdAssConfrmSwDscmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwDscmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb731d00">
                  <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssMesg/NrwroadBwdAssMesg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadBwdAssMesg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssMesg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb72fa00">
                  <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwSts/NrwroadBwdAssSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadBwdAssSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb713300">
                  <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdBtnDsp/NrwroadFwdBtnDsp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdBtnDsp</SHORT-LABEL>
                          <VALUE>0x3</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb715600">
                  <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdCndNotSt/NrwroadFwdCndNotSt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdCndNotSt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCndNotSt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb717900">
                  <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDsp/NrwroadFwdDsp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDsp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb719c00">
                  <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDst360Req/NrwroadFwdDst360Req</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDst360Req</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDst360Req</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb71bf00">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstBtnDsp/NrwroadFwdDstBtnDsp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDstBtnDsp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb71e200">
                  <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstL/NrwroadFwdDstL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDstL</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb720500">
                  <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstR/NrwroadFwdDstR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDstR</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb722800">
                  <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstTostDsp/NrwroadFwdDstTostDsp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdDstTostDsp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstTostDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb724b00">
                  <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdReDst/NrwroadFwdReDst</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdReDst</SHORT-LABEL>
                          <VALUE>0x7FF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReDst</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb726e00">
                  <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdSta/NrwroadFwdSta</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdSta</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb729100">
                  <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdSwSts/NrwroadFwdSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdSwSts</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb72b400">
                  <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadsltSta/NrwroadsltSta</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadsltSta</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6d3c00">
                  <SHORT-NAME>PDCSysSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PDCSysSts/PDCSysSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PDCSysSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDCSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb79d000">
                  <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PDSysKeyPsAvlbl/PDSysKeyPsAvlbl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PDSysKeyPsAvlbl</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDSysKeyPsAvlbl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb777d00">
                  <SHORT-NAME>PEBSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSts/PEBSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PEBSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb775a00">
                  <SHORT-NAME>PEBSwResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSwResp/PEBSwResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PEBSwResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb773700">
                  <SHORT-NAME>PEBWarngReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBWarngReq/PEBWarngReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PEBWarngReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBWarngReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb95ac00">
                  <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirAvlSts/ParkngDirAvlSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngDirAvlSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb958900">
                  <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirSwResp/ParkngDirSwResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngDirSwResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb956600">
                  <SHORT-NAME>ParkngEndDis</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngEndDis/ParkngEndDis</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngEndDis</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngEndDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb79ad00">
                  <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngInPrgs/ParkngInPrgs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngInPrgs</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngInPrgs</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9f7900">
                  <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngNCPAvlSts/ParkngNCPAvlSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngNCPAvlSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngNCPAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6b5200">
                  <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkCrsSts/ParkngOutBkCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutBkCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6b7500">
                  <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkLCrsSts/ParkngOutBkLCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutBkLCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6b9800">
                  <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkRCrsSts/ParkngOutBkRCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutBkRCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb736300">
                  <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutDircnSelResult/ParkngOutDircnSelResult</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutDircnSelResult</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutDircnSelResult</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6aa300">
                  <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFLCrsSts/ParkngOutFLCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutFLCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6ac600">
                  <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFLParllSts/ParkngOutFLParllSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutFLParllSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6ae900">
                  <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFRCrsSts/ParkngOutFRCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutFRCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6b0c00">
                  <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFRParllSts/ParkngOutFRParllSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutFRParllSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6b2f00">
                  <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFrtCrsSts/ParkngOutFrtCrsSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngOutFrtCrsSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFrtCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6bbb00">
                  <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngSlotFindSts/ParkngSlotFindSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngSlotFindSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSlotFindSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f498f2acb2081400">
                  <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngSpdSwResp/ParkngSpdSwResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngSpdSwResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSpdSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba29900">
                  <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysADASFltSts/PilotSysADASFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysADASFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysADASFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba2bc00">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrF1FltSts/PilotSysAVCamrF1FltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrF1FltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF1FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba2df00">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrF3FltSts/PilotSysAVCamrF3FltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrF3FltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF3FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba32500">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrFLSFltSts/PilotSysAVCamrFLSFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrFLSFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba34800">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrFRSFltSts/PilotSysAVCamrFRSFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrFRSFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba30200">
                  <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRFltSts/PilotSysAVCamrRFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrRFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba36b00">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRLSFltSts/PilotSysAVCamrRLSFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrRLSFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba38e00">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRRSFltSts/PilotSysAVCamrRRSFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysAVCamrRRSFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba43d00">
                  <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysFDRFltSts/PilotSysFDRFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysFDRFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFDRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba4ec00">
                  <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysFLIDARFltSts/PilotSysFLIDARFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysFLIDARFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFLIDARFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba3b100">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrFFltSts/PilotSysHDAVMCamrFFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysHDAVMCamrFFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrFFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba3f700">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrLHFltSts/PilotSysHDAVMCamrLHFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysHDAVMCamrLHFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrLHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba3d400">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRFltSts/PilotSysHDAVMCamrRFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysHDAVMCamrRFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba41a00">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRHFltSts/PilotSysHDAVMCamrRHFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysHDAVMCamrRHFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba46000">
                  <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysLFSDAFltSts/PilotSysLFSDAFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysLFSDAFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba4a600">
                  <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysLHRDAFltSts/PilotSysLHRDAFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysLHRDAFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb405700">
                  <SHORT-NAME>PilotSysMsg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysMsg/PilotSysMsg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysMsg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba48300">
                  <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysRFSDAFltSts/PilotSysRFSDAFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysRFSDAFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba4c900">
                  <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysRHRDAFltSts/PilotSysRHRDAFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysRHRDAFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba50f00">
                  <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysUSSFltSts/PilotSysUSSFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PilotSysUSSFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysUSSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbae8600">
                  <SHORT-NAME>PosALCFailed</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PosALCFailed/PosALCFailed</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PosALCFailed</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PosALCFailed</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaea900">
                  <SHORT-NAME>PrvOutSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PrvOutSts/PrvOutSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PrvOutSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PrvOutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb708400">
                  <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RAAlrWorDis/RAAlrWorDis</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RAAlrWorDis</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RAAlrWorDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb703e00">
                  <SHORT-NAME>RADSSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RADSSwSts/RADSSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RADSSwSts</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RADSSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb706100">
                  <SHORT-NAME>RASysSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RASysSts/RASysSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RASysSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RASysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb701b00">
                  <SHORT-NAME>RFCTWrnng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFCTWrnng/RFCTWrnng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RFCTWrnng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6c6a00">
                  <SHORT-NAME>RLObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLObsRng/RLObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb75b600">
                  <SHORT-NAME>RLSObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSObsRng/RLSObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLSObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb747b00">
                  <SHORT-NAME>RLSUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSUSSSts/RLSUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLSUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6deb00">
                  <SHORT-NAME>RLSideObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSideObsRng/RLSideObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLSideObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb749e00">
                  <SHORT-NAME>RLUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLUSSSts/RLUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb74c100">
                  <SHORT-NAME>RMLUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RMLUSSSts/RMLUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RMLUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb74e400">
                  <SHORT-NAME>RMRUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RMRUSSSts/RMRUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RMRUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5d2b00">
                  <SHORT-NAME>RPShockDistL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RPShockDistL/RPShockDistL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RPShockDistL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5d4e00">
                  <SHORT-NAME>RPShockDistR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RPShockDistR/RPShockDistR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RPShockDistR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6cb000">
                  <SHORT-NAME>RRObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRObsRng/RRObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb759300">
                  <SHORT-NAME>RRSObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSObsRng/RRSObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRSObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb750700">
                  <SHORT-NAME>RRSUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSUSSSts/RRSUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRSUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6e0e00">
                  <SHORT-NAME>RRSideObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSideObsRng/RRSideObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRSideObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb752a00">
                  <SHORT-NAME>RRUSSSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRUSSSts/RRUSSSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRUSSSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaecc00">
                  <SHORT-NAME>RoadHeightL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadHeightL/RoadHeightL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadHeightL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaeef00">
                  <SHORT-NAME>RoadHeightR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadHeightR/RoadHeightR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadHeightR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5d7100">
                  <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL/RoadProfileShockConfidenceL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaf1200">
                  <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL1/RoadProfileShockConfidenceL1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceL1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaf3500">
                  <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL2/RoadProfileShockConfidenceL2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceL2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaf5800">
                  <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL3/RoadProfileShockConfidenceL3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceL3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5d9400">
                  <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR/RoadProfileShockConfidenceR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaf7b00">
                  <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR1/RoadProfileShockConfidenceR1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceR1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaf9e00">
                  <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR2/RoadProfileShockConfidenceR2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceR2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbafc100">
                  <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR3/RoadProfileShockConfidenceR3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockConfidenceR3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5db700">
                  <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL/RoadProfileShockDetectedL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb21400">
                  <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL1/RoadProfileShockDetectedL1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedL1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbafe400">
                  <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL2/RoadProfileShockDetectedL2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedL2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb00700">
                  <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL3/RoadProfileShockDetectedL3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedL3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5dda00">
                  <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR/RoadProfileShockDetectedR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb23700">
                  <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR1/RoadProfileShockDetectedR1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedR1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb02a00">
                  <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR2/RoadProfileShockDetectedR2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedR2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb04d00">
                  <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR3/RoadProfileShockDetectedR3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDetectedR3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb07000">
                  <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL1/RoadProfileShockDistL1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistL1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb09300">
                  <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL2/RoadProfileShockDistL2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistL2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb0b600">
                  <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL3/RoadProfileShockDistL3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistL3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb0d900">
                  <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR1/RoadProfileShockDistR1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistR1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb0fc00">
                  <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR2/RoadProfileShockDistR2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistR2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb11f00">
                  <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR3/RoadProfileShockDistR3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockDistR3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5dfd00">
                  <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL/RoadProfileShockHeightL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb14200">
                  <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL1/RoadProfileShockHeightL1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightL1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb16500">
                  <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL2/RoadProfileShockHeightL2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightL2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb18800">
                  <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL3/RoadProfileShockHeightL3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightL3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5e2000">
                  <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR/RoadProfileShockHeightR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb1ab00">
                  <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR1/RoadProfileShockHeightR1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightR1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb1ce00">
                  <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR2/RoadProfileShockHeightR2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightR2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb1f100">
                  <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR3/RoadProfileShockHeightR3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockHeightR3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5e4300">
                  <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockLevelL/RoadProfileShockLevelL</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockLevelL</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5e6600">
                  <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockLevelR/RoadProfileShockLevelR</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RoadProfileShockLevelR</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6cd300">
                  <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrMidLObsRng/RrMidLObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RrMidLObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6c8d00">
                  <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrMidRObsRng/RrMidRObsRng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RrMidRObsRng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6d1900">
                  <SHORT-NAME>RrObsDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrObsDist/RrObsDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RrObsDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6d8200">
                  <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrPDCAudWrnng/RrPDCAudWrnng</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RrPDCAudWrnng</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9e4d00">
                  <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFAudWrnng_IPD/SLIFAudWrnng_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFAudWrnng_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFAudWrnng_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb407a00">
                  <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFSts_IPD/SLIFSts_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFSts_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbc1500">
                  <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFSysFltSts/SLIFSysFltSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFSysFltSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9e7000">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtIndResp_IPD/SLIFUpdtIndResp_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFUpdtIndResp_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndResp_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9e9300">
                  <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtInd_IPD/SLIFUpdtInd_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
