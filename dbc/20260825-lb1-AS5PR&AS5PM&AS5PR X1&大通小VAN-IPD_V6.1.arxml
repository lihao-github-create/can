              <SHORT-NAME>DrvrGazeRgn_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrGazeRgn_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="89e93de927e837799d07cd8ca1fd57f1">
              <SHORT-NAME>DrvrPrst_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrPrst_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="17dcd50395c436b8854c91463199fed9">
              <SHORT-NAME>DrvrReqFrtAxleWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqFrtAxleWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="92704215fd6c3cb784b4be30fd57f604">
              <SHORT-NAME>DrvrReqFrtAxleWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqFrtAxleWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d3a88f0c3733f399d37406c6d1870d3">
              <SHORT-NAME>DrvrReqGearShftPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqGearShftPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="187d2ce848ae34b0aac90c325d8edec7">
              <SHORT-NAME>DrvrReqGearShftPosInvs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqGearShftPosInvs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f71c71a8e9d439b49bd1de44352920b5">
              <SHORT-NAME>DrvrReqOtptRodTrvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqOtptRodTrvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e91cf2272473996b422bbe98440407e">
              <SHORT-NAME>DrvrReqOtptRodTrvlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqOtptRodTrvlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4f4ebd704fb3f44b7ecb06ce7272db1">
              <SHORT-NAME>DrvrReqParkBtn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqParkBtn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b3c4eb1b773361eb0319d946981c651">
              <SHORT-NAME>DrvrReqRrAxleWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqRrAxleWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5ee3c5c0be8d3eec963a1470311ae1bf">
              <SHORT-NAME>DrvrReqRrAxleWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrReqRrAxleWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c454ee2f2f33e48bbd9df640e5badf4">
              <SHORT-NAME>DrvrSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81b10d7f61e43d98be923d2d51f4247c">
              <SHORT-NAME>DrvrSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd924fd9fcad389c9c8251bdc0b74f76">
              <SHORT-NAME>DrvrShftCtrlReqDndIO</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrShftCtrlReqDndIO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="04c31ada95683c18a9f3485dcd4ea3d2">
              <SHORT-NAME>DrvrShftCtrlTrgtGear_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrShftCtrlTrgtGear_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="465878607da735c9b0a3e67e403713f8">
              <SHORT-NAME>DrvrStrgDlvrdToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrStrgDlvrdToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1273856617d031899f68aa9318015eb2">
              <SHORT-NAME>DrvrStrgDlvrdToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DrvrStrgDlvrdToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="971005debb1435cd99dec37c569d9b24">
              <SHORT-NAME>DsblICE_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DsblICE_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a86b6dbd07813f8c82997665d0fe7b0d">
              <SHORT-NAME>DsblISG_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DsblISG_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d58521b13534395c9dec7cde7e95a619">
              <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DschrgOptMaxPwr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a0525b06dd1d3bad91cf1dfa786a0335">
              <SHORT-NAME>DschrgOptMaxPwrV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DschrgOptMaxPwrV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf907efc3ce836f8ad21819893377575">
              <SHORT-NAME>DschrgTrgtSOCVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DschrgTrgtSOCVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6e9560e2b3143fb69a11a193b4d350d1">
              <SHORT-NAME>DspMeasmtSys</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/DspMeasmtSys</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed61cabb9f003879b442fa83fc0c2ffa">
              <SHORT-NAME>EAC_Avlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EAC_Avlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f6e95c351720379e89b472468c7c5dca">
              <SHORT-NAME>EBDA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBDA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d8452f42652353c96049ff82e90d9ee">
              <SHORT-NAME>EBDFaultSt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBDFaultSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4bc82ceef803ad5824061b40479a27b">
              <SHORT-NAME>EBSBatIncnstncyFlag</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBSBatIncnstncyFlag</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0dc70af3bf9e36ae8bd11eec16962676">
              <SHORT-NAME>EBSBatSOFVol1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBSBatSOFVol1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="487ed4229f433ce38a96f9fd55be3182">
              <SHORT-NAME>EBSBatSOFVol1Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBSBatSOFVol1Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2fb93281ed23324fa6e9d050c84b0305">
              <SHORT-NAME>EBSBatSOFVol2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBSBatSOFVol2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6421982a97b2373697d99c4d8b30493d">
              <SHORT-NAME>EBSBatSOFVol2Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EBSBatSOFVol2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f9c7b368ae7b39e98e5e76c7f54a2c08">
              <SHORT-NAME>ECMCoolngFanPWMReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECMCoolngFanPWMReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="495c141d8bb13770b038d3d486fc7b66">
              <SHORT-NAME>ECMCoolngFanPWMReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECMCoolngFanPWMReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ad42843a2237315d8840f37be964da9a">
              <SHORT-NAME>ECM_010ms_Group00_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_010ms_Group00_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="11d74a25d10a3eb3b7b7179063f72fcb">
              <SHORT-NAME>ECM_010ms_Group00_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_010ms_Group00_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="daccd76c5972385b887d8d915697f01d">
              <SHORT-NAME>ECM_010ms_Group00_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_010ms_Group00_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2aabd75500fd3f0f927440e1489a55ac">
              <SHORT-NAME>ECM_010ms_Group00_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_010ms_Group00_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94fd040d170337e685379d2c74161c05">
              <SHORT-NAME>ECM_020ms_PDU03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_020ms_PDU03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c488cd50e7d3a6b977013722f7db4ec">
              <SHORT-NAME>ECM_020ms_PDU03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_020ms_PDU03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20787760d38c3a15810a542e830a02ae">
              <SHORT-NAME>ECM_25ms_Group36_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="18195b767fb03dd7839b19913f6d2b91">
              <SHORT-NAME>ECM_25ms_Group36_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5ca271f72cbe3e349b27b01888c224c1">
              <SHORT-NAME>ECM_25ms_Group36_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e005e6be499c36ec94e4081527d0bb21">
              <SHORT-NAME>ECM_25ms_Group36_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c29b78f5d7f03dc381117a566c1f25fb">
              <SHORT-NAME>ECM_25ms_Group36_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05da3b4203193099ba05389e5fca3290">
              <SHORT-NAME>ECM_25ms_Group36_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf3a32b8b3253e6e96004d4635ff370b">
              <SHORT-NAME>ECM_25ms_Group36_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb32e8a8daba3aac83bb3c32849aebd7">
              <SHORT-NAME>ECM_25ms_Group36_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="77ff776a0e4f3759854eeefb705128c2">
              <SHORT-NAME>ECM_25ms_Group36_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81737c2335cc37b491e9600cecc3daca">
              <SHORT-NAME>ECM_25ms_Group36_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d992e8d94a423925a7b19f7fb375f466">
              <SHORT-NAME>ECM_25ms_Group36_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="058bc06163473daaa12cf56eee612477">
              <SHORT-NAME>ECM_25ms_Group36_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_25ms_Group36_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ffc1d7e396e2317ea0ef8d7bf8bdbfe5">
              <SHORT-NAME>ECM_500ms_group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_500ms_group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c0c8d24f21f3bd29d9223e2fcb9f25e">
              <SHORT-NAME>ECM_500ms_group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_500ms_group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="113b6b3ebb283992bef430f8238649f0">
              <SHORT-NAME>ECM_500ms_group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_500ms_group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6af35e815626322ab912887184bad78e">
              <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_020ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05af503be7993d4d88ea484308599ede">
              <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_020ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="509aa4d6072936cd98d5a94c1994fc13">
              <SHORT-NAME>ECM_ZONE_050ms_Group09_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_050ms_Group09_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65dd3746b51939c9bf4ac9537bfc66b3">
              <SHORT-NAME>ECM_ZONE_050ms_Group09_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_050ms_Group09_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d7d158d4e683ed2960292bf2874958e">
              <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_050ms_Group09_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="adfede19ca95397da6cde956f5d5572a">
              <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_050ms_Group09_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d969fd1cc693dd3b43b346b3634704e">
              <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECM_ZONE_050ms_Group09_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="555b573e1ff23fa4954ada4981d8292f">
              <SHORT-NAME>ECODrvngSpdRutA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ECODrvngSpdRutA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c3539e99304307fb03581d0186bce99">
              <SHORT-NAME>EDRDircnIndLampSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDRDircnIndLampSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="283b096425453245a92cbc59216aea42">
              <SHORT-NAME>EDUClntTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUClntTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="303b022b252e35f9af73c989c4edaab7">
              <SHORT-NAME>EDUClntTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUClntTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="063fbcbb3c2139939d78607be09f4a73">
              <SHORT-NAME>EDUOilPmpMotEnb</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUOilPmpMotEnb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="825894fe63c53c139decf3dbde4bbace">
              <SHORT-NAME>EDUOilPmpMotSpdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUOilPmpMotSpdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e879e7c11a93ee5a8c67714575df3b5">
              <SHORT-NAME>EDUOilTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUOilTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab960b110eb537d2885fa1b2ab736eff">
              <SHORT-NAME>EDUOilTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EDUOilTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="161888c4aab1329cb3668a17a79684d6">
              <SHORT-NAME>ELKDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ELKDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8fb76c55c2e03ec28b1649cad08cce3a">
              <SHORT-NAME>ELKSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ELKSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e98becb96b6333afb55ac4d7bab7c399">
              <SHORT-NAME>ELKSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ELKSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ad8218da4133360c8727c2a441e086cb">
              <SHORT-NAME>ELKSysSts_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ELKSysSts_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5408ede07ffc3cf49f68b821e92c550e">
              <SHORT-NAME>ELKWarning</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ELKWarning</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb7c5298fbf6355c932d85cfb81b0a27">
              <SHORT-NAME>EMCLPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EMCLPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a64e6a55b42b31b6acdccbc5e141c77e">
              <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EORWarningEvtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e27bff93d6e35fd9d830c12e05bd16b">
              <SHORT-NAME>EPBAPAAvlbl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBAPAAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="417b25c69b1f3d3c8897d14e4e0f79a1">
              <SHORT-NAME>EPBAppcnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBAppcnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a71583a7be4035f69ebc72d6f5458d87">
              <SHORT-NAME>EPBAppcnSts_M</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBAppcnSts_M</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="243feb71f74b3ea0a3b158e8ab4ee32f">
              <SHORT-NAME>EPBAvlblySts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBAvlblySts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bbc59368165a37b4bfa8196435b9f1d6">
              <SHORT-NAME>EPBCCCanclReqd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBCCCanclReqd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e89b14f6584e35a88b04765975e70e8d">
              <SHORT-NAME>EPBFlrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ce14a5de94635fca368dc36cfe2dd9b">
              <SHORT-NAME>EPBSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d32b12d5a4f37788adc185c5446f41b">
              <SHORT-NAME>EPBSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aec3893e92983f0088d329fe23aed192">
              <SHORT-NAME>EPBSwStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSwStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fa7556b487f734be97937d37dbbd8108">
              <SHORT-NAME>EPBSysAudWrnngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSysAudWrnngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="09c9b211d46f342baa54adb45104d8cb">
              <SHORT-NAME>EPBSysBrkLghtsReqdA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSysBrkLghtsReqdA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="15c8f1b23cdd3f10b8fbc489c6c072f9">
              <SHORT-NAME>EPBSysDspMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSysDspMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d2651485347391fb0f1ac74b97c8ec6">
              <SHORT-NAME>EPBSysStsIndReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSysStsIndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d7f618b8e4a3719bc360ab61f098dc4">
              <SHORT-NAME>EPBSysWrnngIndReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPBSysWrnngIndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="80b2dcd71c473768bd1e08481ed79b77">
              <SHORT-NAME>EPMCurEstdCapct</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPMCurEstdCapct</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c34285b933934c3a63f2b995757b09f">
              <SHORT-NAME>EPMMaxEstdCapct</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPMMaxEstdCapct</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d7c05000367d3c5ea083714afbd85a96">
              <SHORT-NAME>EPMOprtMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPMOprtMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f700f0c541134d5807ec40ffb0334b8">
              <SHORT-NAME>EPSAESReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAESReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="164963de184130069e17eebb41234db1">
              <SHORT-NAME>EPSAESReqTorResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAESReqTorResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63c5704473453d5aa01dadab03a81c04">
              <SHORT-NAME>EPSAESReqTorRespV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAESReqTorRespV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a6e280cd7d543e6d87886a208003a101">
              <SHORT-NAME>EPSAESStsInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAESStsInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96f81571a3b03506af553a9eba84d820">
              <SHORT-NAME>EPSAIPkgAngReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPkgAngReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca78172cf3d23371bc86f72befe78a69">
              <SHORT-NAME>EPSAIPkgAngReqRespInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPkgAngReqRespInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac99812d0cb2360f9e8053d83d7f0f72">
              <SHORT-NAME>EPSAIPltAngRespSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPltAngRespSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb1b431be73f33c0bb6b93ea2ec9d0ef">
              <SHORT-NAME>EPSAIPltAngRespStsInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPltAngRespStsInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e89a77fbcf33a0781eb0b384286d45f">
              <SHORT-NAME>EPSAIPltAvlLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPltAvlLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="beff45dc6d7a30d38f2d93e00ba555f2">
              <SHORT-NAME>EPSAIPltCtrlChannel</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAIPltCtrlChannel</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="56d23d234b0b33f0b07bb4d99756c696">
              <SHORT-NAME>EPSAPAInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAPAInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21e64b80058e3517b6a7b42d628208a3">
              <SHORT-NAME>EPSAPASts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAPASts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bdc96b71f9c63f098ed76de0987e9234">
              <SHORT-NAME>EPSActRetMotToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSActRetMotToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1e504893b5543fa781f0ac27db4c4783">
              <SHORT-NAME>EPSActRetMotToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSActRetMotToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f923186a3edc36b3b21c1e98dfafa38b">
              <SHORT-NAME>EPSAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72e5fa2487523b0aa94476f677906a19">
              <SHORT-NAME>EPSCTTX</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSCTTX</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dd9a1b213e623a37bde2a785215e193b">
              <SHORT-NAME>EPSCoDrivingSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSCoDrivingSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6bb1d0cdd5cb35b2ab6ab14d6979dac4">
              <SHORT-NAME>EPSCurntDrvMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSCurntDrvMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="decdf1b7aa4e394cb1db8957be9e798f">
              <SHORT-NAME>EPSDrvngMdCtrlInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSDrvngMdCtrlInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="40a91b3540133d45a45adaf5808a2b5b">
              <SHORT-NAME>EPSFlrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="799c6c1a72f2341bb308a95978070d54">
              <SHORT-NAME>EPSLimMotToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSLimMotToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="626cdbd402c83b8cb7befb71542d73e7">
              <SHORT-NAME>EPSLimMotToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSLimMotToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6447ce7198de318f858deef7ee879c14">
              <SHORT-NAME>EPSPriyChnlFlrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSPriyChnlFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="883b0356fc2f33aab551160fdde8922a">
              <SHORT-NAME>EPSToqAppdCoefnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSToqAppdCoefnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c2d285d45dc13822a1b96d14aeb1c94b">
              <SHORT-NAME>EPSToqValAldMax</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSToqValAldMax</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="154fd79a5c8f36e6b0fb68c088d493ac">
              <SHORT-NAME>EPSToqValAldMaxV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSToqValAldMaxV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7384656e90893705a32e43ffae3fccdb">
              <SHORT-NAME>EPSToqValAldMin</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSToqValAldMin</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d7d3811768ab3e5599e503b7c61bd51e">
              <SHORT-NAME>EPSToqValAldMinV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSToqValAldMinV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81292a4f34103531bf8618cb3085e260">
              <SHORT-NAME>EPSVMCAngRespSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSVMCAngRespSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1eeee68abbad3e2c8ea995ad0677b939">
              <SHORT-NAME>EPSVMCCodrivingSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSVMCCodrivingSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b8453e4783e359b98a4b57999ee0673">
              <SHORT-NAME>EPSVMCRespStsInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPSVMCRespStsInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4108a598a8e1350195535fc2df515b55">
              <SHORT-NAME>EPS_010ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_010ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed370efd28d83a2591cef8707948e69b">
              <SHORT-NAME>EPS_010ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_010ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ad58565e5d253d40ace497d94b5c3ca2">
              <SHORT-NAME>EPS_010ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_010ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f706881f1b9233b2a0111f377c7f8228">
              <SHORT-NAME>EPS_010ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_010ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e45bf4b5aa803b0a99a826bf6868ed68">
              <SHORT-NAME>EPS_010ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_010ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6225494cc227329fa8a04eb4c740a9b1">
              <SHORT-NAME>EPS_10ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a1ad8ede4c933f89e2e68ff5cce3326">
              <SHORT-NAME>EPS_10ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d0799f0e4d83678a3208a2e366e6f49">
              <SHORT-NAME>EPS_10ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d61fa5e9e1b3744b3c59cfdd089ee6d">
              <SHORT-NAME>EPS_10ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a5d394654f04346984e57c0fde56ec02">
              <SHORT-NAME>EPS_10ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a475851b59d435c7840661d482554f9c">
              <SHORT-NAME>EPS_10ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbe5f054d64b3884a8a40b44f456f38b">
              <SHORT-NAME>EPS_10ms_Group01_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f66a2e8d9493912801383d7d2634dfa">
              <SHORT-NAME>EPS_10ms_Group01_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5ad6e68b6f26379cb4159e074fd642d5">
              <SHORT-NAME>EPS_10ms_Group01_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f33b42630f33351bb807582a5e5da17">
              <SHORT-NAME>EPS_10ms_Group01_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b44c9a87de5394aa29b1ed787f582a2">
              <SHORT-NAME>EPS_10ms_Group01_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group01_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba7830b0274330b1ab8b35b7eed3f155">
              <SHORT-NAME>EPS_10ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc374322b9a53fd6bc366fddf8fb15de">
              <SHORT-NAME>EPS_10ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95e442fce61132e8a7466ddb8351ee0c">
              <SHORT-NAME>EPS_10ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e3405ccf3fcc35688f733aa90ef7771e">
              <SHORT-NAME>EPS_10ms_Group02_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48cfdf5842b8340697525401b904edbb">
              <SHORT-NAME>EPS_10ms_Group05_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group05_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="278a480243883b098a05374e01777461">
              <SHORT-NAME>EPS_10ms_Group05_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group05_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b8b8a77452c23a3e85845e36713fec0c">
              <SHORT-NAME>EPS_10ms_Group05_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group05_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f775a63d5874371a8eef340acb83c39b">
              <SHORT-NAME>EPS_10ms_Group05_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group05_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="452ed81bb4fd346c96f3bec5d69b75a9">
              <SHORT-NAME>EPS_10ms_Group05_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_10ms_Group05_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e5000afa3bf3a9db9d83e9b61d6d844">
              <SHORT-NAME>EPS_20ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d7ab870d1bcf38debd914f156510bc9b">
              <SHORT-NAME>EPS_20ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="137d9853321632329c5a4e4da6a00be6">
              <SHORT-NAME>EPS_20ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8716af015e093e778d873ee9b2c8e9e7">
              <SHORT-NAME>EPS_20ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aced9435ff5538b58d1b995d9d20f008">
              <SHORT-NAME>EPS_20ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57238b83a277322f8a8507bf03f0c535">
              <SHORT-NAME>EPS_20ms_Group03_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c3e47c51c7c13e6d8f06bbaef23e389b">
              <SHORT-NAME>EPS_20ms_Group03_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_20ms_Group03_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="327d06a5279236b6b086850426dbd45c">
              <SHORT-NAME>EPS_NKI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="714fabd3463636938312de5e4126008f">
              <SHORT-NAME>EPS_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4c80fe10d0932adb2e6231e781b5d97">
              <SHORT-NAME>EPS_NM_NOSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4a77aaef529030dfa8784d60cdb3c008">
              <SHORT-NAME>EPS_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4210a7b7af3e3bc6b7f49a6732db1a5b">
              <SHORT-NAME>EPS_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9cdfe0b83dd93ac4a0f415edf8ee6dfd">
              <SHORT-NAME>EPS_NM_RMSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed9d89d78bdd3e41a1e2bc81f21ffe90">
              <SHORT-NAME>EPS_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="26600548d9bb36569a645da5413b2b4d">
              <SHORT-NAME>EPS_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="235e6bc5ef4b3950bd5280411872869f">
              <SHORT-NAME>EPS_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fe66f9c50300374cb7827a1de5cffd8e">
              <SHORT-NAME>EPS_NOI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1134cea6d2313bffa982be57cc9da6f0">
              <SHORT-NAME>EPS_NWI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPS_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a52f30198113a06827675c27feb03ee">
              <SHORT-NAME>EPTAPARevrDrgReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTAPARevrDrgReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac95c76008733cc2a89d7e08d33342b6">
              <SHORT-NAME>EPTAccelActuPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTAccelActuPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3872b4ff5fae3415a495ec336326fca4">
              <SHORT-NAME>EPTAccelActuPosV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTAccelActuPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac25e3eb8f6c3a838720ff2781fb098f">
              <SHORT-NAME>EPTAccelEfctvPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTAccelEfctvPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32b614d7f66832f1a1c9dd216efc0481">
              <SHORT-NAME>EPTBrkPdlDscrtInptSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTBrkPdlDscrtInptSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c22c082b056b388eb10f8722bf2c1b07">
              <SHORT-NAME>EPTBrkPdlDscrtInptStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTBrkPdlDscrtInptStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2750a8f916893bb494cfcc53532ae021">
              <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTClntPumpSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="45a354d59d653a409fb82024d224ae43">
              <SHORT-NAME>EPTCrkAbotd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTCrkAbotd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a483b3188e33ebe831e2c63e26d116e">
              <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTElecWtrPumpActuSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca67d746a6f53a1588c2b5fcfb094f83">
              <SHORT-NAME>EPTElecWtrPumpTrgtSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTElecWtrPumpTrgtSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd05ff86871237c586c93372f19e12b0">
              <SHORT-NAME>EPTHVDCDCMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTHVDCDCMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4be5c63055023f77baca152d4d61ca9b">
              <SHORT-NAME>EPTHVEmgcPwrOffReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTHVEmgcPwrOffReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb02fd60ceb23c4bab1d99c86f998c7e">
              <SHORT-NAME>EPTMainRelayDrvReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTMainRelayDrvReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="948376a2d75e3995a750e82d90d09a7f">
              <SHORT-NAME>EPTNotReadyReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTNotReadyReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="53fae24c7a8a37dbaa15b5f3cbfa4249">
              <SHORT-NAME>EPTRdy</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTRdy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bac9babbba133270a93e3f6b5531d513">
              <SHORT-NAME>EPTRdyV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTRdyV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b9a36f843f5f3e918fa2f4b682128ba2">
              <SHORT-NAME>EPTRunCrkTrmlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTRunCrkTrmlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6acf4f93400b3635b4fbbfa5dd1c188c">
              <SHORT-NAME>EPTSecyAxleInptShaftSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTSecyAxleInptShaftSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b7eee2c7a84e3905b100c71e08b6c605">
              <SHORT-NAME>EPTSecyAxleInptShaftSpdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTSecyAxleInptShaftSpdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5dca09c9426035bd964bb5de6b6b1426">
              <SHORT-NAME>EPTSimEnSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTSimEnSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e11d300e9fc33a5abdbe34902863e32e">
              <SHORT-NAME>EPTStCmdOn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTStCmdOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec9f607c330e308a961f83bfd5d5d64a">
              <SHORT-NAME>EPTToqCustSetngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTToqCustSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f02416d520d394ebc631142e27a6c29">
              <SHORT-NAME>EPTToqCustSetngReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTToqCustSetngReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b71987b974703082bc6253bac07b3dbf">
              <SHORT-NAME>EPTTrInptShaftSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrInptShaftSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="42246b3a3351354d81984b525da6e5d7">
              <SHORT-NAME>EPTTrInptShaftSpdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrInptShaftSpdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6a291fa4cae36098de17e38f2686686">
              <SHORT-NAME>EPTTrInptShaftSpdV_R</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrInptShaftSpdV_R</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a367be05f7803f58bc698e0a24739da1">
              <SHORT-NAME>EPTTrInptShaftSpd_R</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrInptShaftSpd_R</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2982a7321b9635bcacc8a31e8f756f22">
              <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotMaxAvlblToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6dbd02048425311a86d7dee3441c31e7">
              <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotMaxAvlblToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e1f863bc6f13ce2a32223f79afb213e">
              <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotMinAvlblToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aae0d5becc91311ea84ab28a25dac9da">
              <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotMinAvlblToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae27da843e2f3e818b9a29bfb1d4dfe8">
              <SHORT-NAME>EPTTrOtptShaftTotToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16a1a8a860373ca28089e6bff18b7430">
              <SHORT-NAME>EPTTrOtptShaftTotToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EPTTrOtptShaftTotToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3d0b7f40c6973ae391e0295fcb8ac440">
              <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCBrkRgnPwrLmt_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6bed567693683b129acbe9ade09b8570">
              <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCChrgPwrLmtPeak_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb488e93528634fc88f01b491fd02600">
              <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCChrgPwrLmtWhl_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="583919f267733e6ab897a46ce634671c">
              <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCDsChrgPwrLmtPeak_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1005218b5ce439c7a3137de218d9b077">
              <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCDsChrgPwrLmtWhl_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db7742902de535f988769dd104f6894f">
              <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCEmgcyPwrDwn_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9be65206b5cc312eb8e80d9b9b749822">
              <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCFCOReq_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8360667663ac3f38bb6145beda5324d0">
              <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCHVAllwd_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="642f0ccf7e01326da305cd4baf4a8b3f">
              <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCHVHldReq_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c190659127f83c2f8d73608cc093dc6f">
              <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCMaxChrgPwrLmt_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="41fe1faf835f3a85b7aa7f4db59477e4">
              <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ERCMaxDschgPwrLmt_kW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f0997fc328136de9ba699d1b503fb0b">
              <SHORT-NAME>ESCLAuthnReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESCLAuthnReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c0663e5f31d3fe88eaa83badbfa4d53">
              <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESCLPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dfc1edb46d673958b3b2742c2697f764">
              <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESFStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="84664367a4c634f5a2e777f2bd078ab3">
              <SHORT-NAME>ESSAdoWrnngDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSAdoWrnngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a72c0e77ac9834dcaf335d69770839dc">
              <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSAdoWrnngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9da50cd850833705be4d34eb9c80775f">
              <SHORT-NAME>ESSClntPumpSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSClntPumpSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d87da8a057e3f218f1317305b62538b">
              <SHORT-NAME>ESSDirInd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSDirInd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6297040e26c3f3ca9f9594c20ef1d56">
              <SHORT-NAME>ESSDrvrTkovReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSDrvrTkovReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4618fb45fed136d8ad7d6eb0c61b5485">
              <SHORT-NAME>ESSDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e761e5ad3b73c14b9a8f497e7cf85ea">
              <SHORT-NAME>ESSElecWtrPumpActuSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSElecWtrPumpActuSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="458538b53e8b388ea505535a04700548">
              <SHORT-NAME>ESSElecWtrPumpTrgtSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSElecWtrPumpTrgtSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52cee16085cc363bb3334ebfa29baf1c">
              <SHORT-NAME>ESSPTCHVILSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSPTCHVILSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f042cd3d72d3dca91d1369504d420c2">
              <SHORT-NAME>ESSPTCHVILStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSPTCHVILStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcda966450a63addb8510fe62fa02b36">
              <SHORT-NAME>ESSSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b5da37fe456a3e52b8ae1d1d447dc02d">
              <SHORT-NAME>ESSSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac6946a254963532a7184028d457f6eb">
              <SHORT-NAME>ESS_100ms_Group25_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c68d2d9bebe93cf888f2b61df8ff56a1">
              <SHORT-NAME>ESS_100ms_Group25_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7015636f43e3161b725d6a884713966">
              <SHORT-NAME>ESS_100ms_Group25_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ffe1f3474643152b62d2f7703a958ed">
              <SHORT-NAME>ESS_100ms_Group25_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="03ca6f0caa503b868f1cb5da79151a22">
              <SHORT-NAME>ESS_100ms_Group25_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="549bc48f5f9e312794d6d56dbfc254dd">
              <SHORT-NAME>ESS_100ms_Group25_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group25_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9941b6fc49cf3b6ba33b193ee2615b2d">
              <SHORT-NAME>ESS_100ms_Group58_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc50ffe53b343c58abd15c85c43d5a34">
              <SHORT-NAME>ESS_100ms_Group58_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="288620554ad03305b862320f099cdd4e">
              <SHORT-NAME>ESS_100ms_Group58_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bdb41cd4b59f344e952ec10b7b4618c2">
              <SHORT-NAME>ESS_100ms_Group58_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3acdf91ecd6b317a8022cb4b69ca1e93">
              <SHORT-NAME>ESS_100ms_Group58_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="514c8dd4e3e439759bf3b8691f022b64">
              <SHORT-NAME>ESS_100ms_Group58_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b5eea28f62a737caba276f6b0dd8bffb">
              <SHORT-NAME>ESS_100ms_Group58_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63a5bce7776136efaa507893360f70b8">
              <SHORT-NAME>ESS_100ms_Group58_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f78652b0c8413c7b9323b9e0e6af0108">
              <SHORT-NAME>ESS_100ms_Group58_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_100ms_Group58_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="afdc3a45f5f23902bc5f3edaaffe308b">
              <SHORT-NAME>ESS_ExtdAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bcfde6d7f3143813a6d5fca8813e677c">
              <SHORT-NAME>ESS_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbbdf9a8431c3d62acd3d3c55d725d15">
              <SHORT-NAME>ESS_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="19c1435769453eaa9b0977e28f36ebab">
              <SHORT-NAME>ESS_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c344233e035340e87f6ac8dcc925947">
              <SHORT-NAME>ESS_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="76436e1b364f3c14b899a7dab2e3da51">
              <SHORT-NAME>ESS_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc8783bfbdcf3b06b7f73c085acce8e4">
              <SHORT-NAME>ESS_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="403f275e6afa3b60b459cc9c6af2bed9">
              <SHORT-NAME>ESS_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f904f75f1083cd7b23e8932e3ce5bdb">
              <SHORT-NAME>ESS_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ec66f0e07463c07b6bcc175526e0073">
              <SHORT-NAME>ESS_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee01077a490230a483945eb1b9bc0813">
              <SHORT-NAME>ESS_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c7f2864c6033aaeaedb151ad658c211">
              <SHORT-NAME>ESS_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0287cfef9d5e3c3d99ea11fe3eefcd5d">
              <SHORT-NAME>ESS_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESS_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="43075dfc62f633b1a8208c1e3bf8530b">
              <SHORT-NAME>ESSswReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ESSswReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24d2f8c03617329e9bd0f9310e6c6ed8">
              <SHORT-NAME>ETCMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ETCMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0aa2bc90345433e7abc71f05cd6e69ee">
              <SHORT-NAME>EVMd_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EVMd_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f4b6d74fd328302eb44d6b3aca3a3987">
              <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EastVelocityRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2c3ca5b735ad3dbcb4044799244fea28">
              <SHORT-NAME>EcoDrvngAIO</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EcoDrvngAIO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e70a1fa1e4f3a2a80dae22a073f9332">
              <SHORT-NAME>EcoDrvngDspStsGearShftIndSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EcoDrvngDspStsGearShftIndSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="473af2f9dc4532d2820b5ac7b8798e9a">
              <SHORT-NAME>EcoDrvngDspStsRcmndFwdGear</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EcoDrvngDspStsRcmndFwdGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="605bf871ed403b348e186ceeb278801b">
              <SHORT-NAME>ElecMotEmgcShutDwn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ElecMotEmgcShutDwn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc9a7406c6d1388db36e0631d7c76b94">
              <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ElecPwrDistbnScene</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="700661e27690396291c54326f0ae094b">
              <SHORT-NAME>EleccLckCtrlResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EleccLckCtrlResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21b2fbe50597325da7e5db145e883679">
              <SHORT-NAME>EleccTrRngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EleccTrRngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4688805b4ba2322fb496116be536114c">
              <SHORT-NAME>EmgcBrkA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EmgcBrkA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d1b848942da35dfa2977901a67b95f5">
              <SHORT-NAME>EmgcBrkAV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EmgcBrkAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc4b5ae13b003fe58ae756bb03c0de20">
              <SHORT-NAME>EmgcBrkReqdByIECUSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EmgcBrkReqdByIECUSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a2446c088b7c3509b72fd002449c97bd">
              <SHORT-NAME>EmmsnTestMdFICM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EmmsnTestMdFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="179f100fb0bf346eb30b79678356b1f8">
              <SHORT-NAME>EmmsnTestMdFICMV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EmmsnTestMdFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="905f11a1828b39e89b4ef3576f2a04d6">
              <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/En12VoltStrMotCmddOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="42826675c623340686bde0b27c215772">
              <SHORT-NAME>EnASSFrngDet</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnASSFrngDet</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a211336ea9c3b2f86301d3f694ce81d">
              <SHORT-NAME>EnASSFuelReqdOn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnASSFuelReqdOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82fe6488530439059cd729e83fdb860d">
              <SHORT-NAME>EnASSSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnASSSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="917189fc99683ab59089f3df1ec0bdbf">
              <SHORT-NAME>EnASSStallDet</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnASSStallDet</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="156dc6a21a243233bc6659f8f55c1c50">
              <SHORT-NAME>EnActuStdyStaToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnActuStdyStaToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a7355e5f80732f48701f35529e17818">
              <SHORT-NAME>EnActuStdyStaToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnActuStdyStaToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="acad280162013e09a91775469ff11cab">
              <SHORT-NAME>EnAutoSpNotProb</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnAutoSpNotProb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb48c5eb174f3ec293c1e661e7522a96">
              <SHORT-NAME>EnCCMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnCCMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="43da65207bf1313099c7c44aa6a86202">
              <SHORT-NAME>EnCalcLdValOBD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnCalcLdValOBD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2d53b7435f953a529e68a26bc0dc2de7">
              <SHORT-NAME>EnClntTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnClntTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb72860d2bf03eb3a89f4b33d5e1238a">
              <SHORT-NAME>EnClntTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnClntTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d3941175823f3477935b4b503d75a098">
              <SHORT-NAME>EnClntTrtTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnClntTrtTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="412018d83b5e3a8ba8b5dff07c92120d">
              <SHORT-NAME>EnComFlrRducdPwrCmdd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnComFlrRducdPwrCmdd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e987d61dff83f6b9e7760e7be1e66ac">
              <SHORT-NAME>EnCtrlrRunCrkTrmlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnCtrlrRunCrkTrmlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f51e490a5e3134cb8687d2f5a4533197">
              <SHORT-NAME>EnDclFuelCutOffAld</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnDclFuelCutOffAld</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31dffbd247823c36bf773c3294dc79c9">
              <SHORT-NAME>EnDclFuelCutOffReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnDclFuelCutOffReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b3a279f5a3d838c89f474bf415012c72">
              <SHORT-NAME>EnDclFuelCutOffSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnDclFuelCutOffSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="595de373e75036af978f47ae914be4fa">
              <SHORT-NAME>EnDragToqRducnA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnDragToqRducnA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e923b2b83c0384580b47a48511473b7">
              <SHORT-NAME>EnDrvngCycCrtra</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnDrvngCycCrtra</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="86af7fe3a3e2369e9f7c52a52a1dfce6">
              <SHORT-NAME>EnEleclMainWtrPumpActuSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnEleclMainWtrPumpActuSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ddd396e2d81342a8212c9d755877d1f">
              <SHORT-NAME>EnFuelCsumpEfncy</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnFuelCsumpEfncy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b276aa31f1136179b74ed1324908be6">
              <SHORT-NAME>EnFuelCutA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnFuelCutA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bee7d4b07b7233b89593899646cd9fb5">
              <SHORT-NAME>EnFuelRcvrySpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnFuelRcvrySpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c09b75318d693f4d8844d9794a2e9d70">
              <SHORT-NAME>EnGPFLampOnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnGPFLampOnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e5af65df563d3991826a50aaf8e590ee">
              <SHORT-NAME>EnHybVehStaOvrd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnHybVehStaOvrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c728539e8496352b960e654cf7861d93">
              <SHORT-NAME>EnIdleCtrlA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnIdleCtrlA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a1578c9de07b3d05876bd76d382eb3e1">
              <SHORT-NAME>EnIdleCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnIdleCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="083bc8715fe13f8fac9faaf0c61bf8e2">
              <SHORT-NAME>EnIntkAirTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnIntkAirTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f1d8998edcd535c897a0827cbd8e6925">
              <SHORT-NAME>EnIntkAirTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnIntkAirTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="19b6d7b6580434bead8f70d9e84bb008">
              <SHORT-NAME>EnReqdStTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnReqdStTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d6dff20b237a3227ae0b5ccb10c255e1">
              <SHORT-NAME>EnRunA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnRunA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b45116a1e94834c08a6f4e068466530d">
              <SHORT-NAME>EnSpReqToTr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSpReqToTr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="caabce2c1ec3321f9adf40f9effb6d3f">
              <SHORT-NAME>EnSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="106735b89a503dbf9a449777eecd3580">
              <SHORT-NAME>EnSpdOBD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSpdOBD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c371a61a41634469a03cd01d9c8a65c">
              <SHORT-NAME>EnSpdSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSpdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="11c9bff454e73057a7aaa80db9b61f9b">
              <SHORT-NAME>EnStCtrlA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnStCtrlA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="73721119a3fb348197ee3f68c4fba834">
              <SHORT-NAME>EnSynRdy</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSynRdy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96cb5e67a33b3f17b8cb107b784a503d">
              <SHORT-NAME>EnSysDsbld</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnSysDsbld</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c8cc05cec5c3700a96696dce6af8396">
              <SHORT-NAME>EnTestMdEnbReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnTestMdEnbReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72161c8d0bfd3df7b09889d049d9aedb">
              <SHORT-NAME>EnToqActuExtdRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqActuExtdRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2baabdcbf64c3cc7bc84c9ecc487f294">
              <SHORT-NAME>EnToqActuExtdRngV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqActuExtdRngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2234cb967553a1f90cab158ca5f6a45">
              <SHORT-NAME>EnToqDrvrReqdExtdRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqDrvrReqdExtdRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a88fabd2a8037a6a4960a378fab0ac7">
              <SHORT-NAME>EnToqDrvrReqdExtdRngV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqDrvrReqdExtdRngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a0d50ef5c8f3c31baad629278c194c0">
              <SHORT-NAME>EnToqMaxExtdRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqMaxExtdRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="276aa8ce115b3d908fb2b0324936e77d">
              <SHORT-NAME>EnToqMaxExtdRngV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqMaxExtdRngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa5cabd8fba1372aa620b9731f475f92">
              <SHORT-NAME>EnToqMinExtdRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqMinExtdRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99f138f87a693739ab6b28317e415fc1">
              <SHORT-NAME>EnToqMinExtdRngV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqMinExtdRngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f503d72bd817311aa06971aa529c6942">
              <SHORT-NAME>EnToqRducnFlrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnToqRducnFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94e9ccd6f10b347abf1bf53dd85cdacf">
              <SHORT-NAME>EnWarmUpCycAch</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnWarmUpCycAch</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a09a966e3c263b0faacd6dc687e8fe78">
              <SHORT-NAME>EndSocTrgtHCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EndSocTrgtHCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b393ef3f5ff233d086510af3085ec9fa">
              <SHORT-NAME>EndSocTrgtHCUV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EndSocTrgtHCUV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31ae22d1ed0d31b6aafa1326bb77e683">
              <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngBrkTqMax_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="888ea770289f348fa751d1059905cb15">
              <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngFastTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="718ae825123234e980f452aaa3a026a2">
              <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngFastTqTypReq_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="939bc4e7b64a3dd78c1645686eef80a3">
              <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngFlexplateTqFstTgt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4453e4d7b4e327fb9beb1ea4822fce2">
              <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngFlexplateTqSlowTgt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c0bb9e521d14309a8a62505ff0522fa2">
              <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngPhsAng_deg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5f1805d2283c3704918a381e8b4bb681">
              <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngSlowTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4490293c38da34ffb1a6b5c8b0ee9b33">
              <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngSpdSafe4EngStrt_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1272b1fa0980333eb5b4c867a5f241b7">
              <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStallCnt_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62389d93517d366c9b8b60716dfa9341">
              <SHORT-NAME>EngStall_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStall_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ce2c84be3bd301ca9210b16cfe4ae15">
              <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStopReqCfmd_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9108e02669d349cb2e1e2ab849510ac">
              <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtDampSlipFailCnt_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13bbe5a0a687384f83cd2b5bccf1532b">
              <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtFailCnt_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6bf01cc8f5c35c4a0e092297e26c4b1">
              <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtFail_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e963480d40ea361eb2d60b259b1464d1">
              <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtNoCapFailCnt_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01596628c2c13979bfda2262d703e68d">
              <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtReq_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5976a20066c93d1cb8a03ebbe3ec83aa">
              <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EngStrtStuckFailCnt_cnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c309bb1577933064b501108a88577830">
              <SHORT-NAME>EnrgSplReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnrgSplReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6e22073eb8873e0fa7e2fab98fa560c4">
              <SHORT-NAME>EnrgSplReqRaw</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnrgSplReqRaw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc740a5091743e4ab79ee23fe442536d">
              <SHORT-NAME>EnrgSplReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EnrgSplReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc45a8e41aa539c190416792595e91bc">
              <SHORT-NAME>EvtPotclSigIPD1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e89ddaec2823878ad6d50b78b354eac">
              <SHORT-NAME>EvtPotclSigIPD2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc55814cecdb35c38636e45611a7fbdf">
              <SHORT-NAME>EvtPotclSigIPD3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d0058246c2b133a9a94d7e654b5796e6">
              <SHORT-NAME>EvtPotclSigIPD4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8f61d942b4836dc8cf9b030c35a574d">
              <SHORT-NAME>EvtPotclSigIPD5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf67ce8ec9e533dda701b5b922c7d125">
              <SHORT-NAME>EvtPotclSigIPD6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1903abddbf833955b118901d5be6a622">
              <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="983fef1c32ad394ba4e242dc72c6217e">
              <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EvtPotclSigIPD8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99b7c9f256423158a71fa2d69d2c6a3f">
              <SHORT-NAME>ExtnlBrkPrio</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ExtnlBrkPrio</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="446372c4701b386aa80d4e2688db142e">
              <SHORT-NAME>ExtnlBrkPrioV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ExtnlBrkPrioV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d02d18a248a3e16bd6a13e5dea00442">
              <SHORT-NAME>ExtnlTstrDet</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ExtnlTstrDet</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="edeb8116d64734c1889f7024a29bb523">
              <SHORT-NAME>ExtrLckActnIndcn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ExtrLckActnIndcn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61b28411f12a3eaaa833ad7bb197bc6d">
              <SHORT-NAME>EyeGazepitch_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeGazepitch_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="247de6d0286c37e09475b778c39e377a">
              <SHORT-NAME>EyeGazeyaw_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeGazeyaw_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cba022a559273500802e0fb9a1db051f">
              <SHORT-NAME>EyeOffRoadDetnSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeOffRoadDetnSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb2e54e52bcd3d8a87f614e7d211a015">
              <SHORT-NAME>EyeOffRoadDetnStaV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeOffRoadDetnStaV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="024dd9bab2cf32ffbc1dcd5c25fdb5c7">
              <SHORT-NAME>EyeOnRoad_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeOnRoad_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f6f2e9a55af93bb99cceffe901ce39b0">
              <SHORT-NAME>EyeOpenDegree_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeOpenDegree_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e5e958689f483ee6bfd63cdb3fd0b7ee">
              <SHORT-NAME>EyeOpenStatus_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/EyeOpenStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8440feb3e053132b0c2e5d4e7bf9b79">
              <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTBSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d2478bb5ba43eb280be50db42b4b368">
              <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTBSysFltSts_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2c18a707402d3d09a2dec88697061dfc">
              <SHORT-NAME>FCTSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="afb73864299434c6be6ec2c07c2286a0">
              <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTSwSts_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e5d5e87530531cd933c3031e9911418">
              <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="592cc5861f0a3e3695f9c6d0c53f5cce">
              <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTSysFltSts_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="adcc4f73ecfa38c7a3f5155f7b933b21">
              <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCTSysSelReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f8bc376c4f243bb49d91253b13d384ab">
              <SHORT-NAME>FCWDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="87a4763229183598b983c42a378156db">
              <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWSnstvtLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee3fbcab4d793a7681dac47c50e2293a">
              <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWSnstvtLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3357fc34d09633cb9b6018341ec99b90">
              <SHORT-NAME>FCWSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5bc73037449a39b4a52e701615bd2b42">
              <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="547217033a883e4b9f5f2ed6076ba5b4">
              <SHORT-NAME>FCWrnngSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FCWrnngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c0d69ea8abe632dc86493be9abf2b82b">
              <SHORT-NAME>FDRAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDRAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ceb15465d78c3e2088c051c355a2ae93">
              <SHORT-NAME>FDRPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDRPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1bb2acf9827b3f468f387086d8187a7a">
              <SHORT-NAME>FDRSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDRSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ddc26ebd34a4307ab1e14e76700ca966">
              <SHORT-NAME>FDR_100ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="125951e05fd63b84968dc57b9dcf0b8a">
              <SHORT-NAME>FDR_100ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd4926d7289a307684d7168c1f40708b">
              <SHORT-NAME>FDR_100ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24ac8c6babd73913bb67feacdde6b40f">
              <SHORT-NAME>FDR_100ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6652347d05253db8b2188c8a6e64453a">
              <SHORT-NAME>FDR_100ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd9d684e4e4734bea13ea3c3e1ef07e1">
              <SHORT-NAME>FDR_100ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="636e2c52bb273203b2a4adf9a24b114f">
              <SHORT-NAME>FDR_100ms_Group01_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9924a489b6483fa3b1970186f82b6c4a">
              <SHORT-NAME>FDR_100ms_Group01_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b9c4b431e6a539748cea53016b9ff2d4">
              <SHORT-NAME>FDR_100ms_Group01_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_100ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a71c97aeaf253aa586eca40844d0786b">
              <SHORT-NAME>FDR_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5710d476cdd4326689cbe4cd32eb7fee">
              <SHORT-NAME>FDR_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="306593fcef8e32a09a917135c7528094">
              <SHORT-NAME>FDR_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a8141f0bba23d4fbef72db094b06e7e">
              <SHORT-NAME>FDR_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6366645876c3377fb79c5c07e8ac037a">
              <SHORT-NAME>FDR_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1456b5cb3b5731e092d70510b0df079d">
              <SHORT-NAME>FDR_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c2a0fe26f1e35098d0db2b50b20010d">
              <SHORT-NAME>FDR_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f1fe40c0c37439ab99f9110131c3c6bb">
              <SHORT-NAME>FDR_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d74303a71a533fd79e4a590d087dc15e">
              <SHORT-NAME>FDR_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99139522216633ad8655e176bcf62c71">
              <SHORT-NAME>FDR_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="734b3b7e457f36438dcbe345e0395188">
              <SHORT-NAME>FDR_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FDR_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b34222e67b1a338abdcf85ca57bc9ef3">
              <SHORT-NAME>FICMACAutoSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACAutoSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb442a9e6fe33a7c99e8cfed3a9fa60a">
              <SHORT-NAME>FICMACFreshSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACFreshSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="af929c0ce82e37d083e73f65ee519419">
              <SHORT-NAME>FICMACFrtBlwrLvlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACFrtBlwrLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="106654bb78043d4084b602a25b47f2e3">
              <SHORT-NAME>FICMACFrtBlwrSpdDecSwR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACFrtBlwrSpdDecSwR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="abf7132e36f13db6a939efed48267206">
              <SHORT-NAME>FICMACFrtBlwrSpdIncSwR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACFrtBlwrSpdIncSwR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c52f1a826c83f62ba569759cbf190a9">
              <SHORT-NAME>FICMACIonizerReqSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACIonizerReqSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbb5aed6eec838b0832d356db58c71ae">
              <SHORT-NAME>FICMACLAirMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLAirMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="edd6cfb8141f3a9c8488e5ede1d85d51">
              <SHORT-NAME>FICMACLAirMdReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLAirMdReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7aac0bc388723d23b378714023ad927d">
              <SHORT-NAME>FICMACLAirMdSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLAirMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79207349f1933010a36e7cc3dd9cdb3c">
              <SHORT-NAME>FICMACLTemDecSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLTemDecSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cae5bcc1088c396f957b832358d64425">
              <SHORT-NAME>FICMACLTemIncSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLTemIncSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ac49774b6c73aefa8f5722c69c763d6">
              <SHORT-NAME>FICMACLTemReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLTemReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ad8706b47b430fba92dfc4cc291bf24">
              <SHORT-NAME>FICMACLTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACLTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="657ce92c00a6372598299d01760bc262">
              <SHORT-NAME>FICMACOnOffSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACOnOffSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5530a208fc643d77ac0610f9851e32d0">
              <SHORT-NAME>FICMACRAirMdSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRAirMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="add780660e29336bbf3955d7eb50f398">
              <SHORT-NAME>FICMACRTemDecSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRTemDecSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64afc9fac4603cd2809fc5371ab1fed5">
              <SHORT-NAME>FICMACRTemIncSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRTemIncSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e724149e7d8d3244a43ba37eff3966d3">
              <SHORT-NAME>FICMACRTemReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRTemReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="945e30b7e26c3e3abf83c9c80a1d3e7d">
              <SHORT-NAME>FICMACRTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f6b841f3cf33cca95fdb24392399564">
              <SHORT-NAME>FICMACRcctnMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRcctnMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ee3e5e92c4b3e1f8f57922efc24e3b8">
              <SHORT-NAME>FICMACRcctnSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACRcctnSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7502e628778a350b844f2e6819f7eec5">
              <SHORT-NAME>FICMACSemiAutoSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACSemiAutoSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ea4a8f76fdc329bbd2e0df099a637ac">
              <SHORT-NAME>FICMACSyncSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMACSyncSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="608ac4028d383a5ca2d24e85ebe9ede8">
              <SHORT-NAME>FICMAirClnrBlwrLvlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMAirClnrBlwrLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3af3164a7a93ed194cb13e9360f43ba">
              <SHORT-NAME>FICMChrgSttnMchngSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMChrgSttnMchngSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6cc06cd9e26638f48ddac0e74516b809">
              <SHORT-NAME>FICMClmOnOffSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMClmOnOffSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6f2f95a6e57539a2a88110d531490522">
              <SHORT-NAME>FICMComprOnOffSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMComprOnOffSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ee0eaf92f6d3baba445f95a340194c6">
              <SHORT-NAME>FICMDfstOnSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMDfstOnSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc51d57b71b53ac7b0e3f333bf8c5441">
              <SHORT-NAME>FICMHtdRrWndSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMHtdRrWndSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b28e5fcba61b36e1aa771e076921cc83">
              <SHORT-NAME>FICMIFPACOnOffSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMIFPACOnOffSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b094884f3ec034bfbcc5b952cb5684d5">
              <SHORT-NAME>FICMInnrDschrgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMInnrDschrgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c4cfef5c00553faca25f1a07eda3a60c">
              <SHORT-NAME>FICMPwrDMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMPwrDMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01b51fde88053a7d8391831828aa4104">
              <SHORT-NAME>FICMPwrDMdReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMPwrDMdReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a24e82fa7b230799e90bccdd6976671">
              <SHORT-NAME>FICMPwrDMdReqV_AIHEV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMPwrDMdReqV_AIHEV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e5fa9b6e30d43720b15a45905f9e0f21">
              <SHORT-NAME>FICMPwrDMdReq_AIHEV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMPwrDMdReq_AIHEV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd606bc6cf4c314cbab8f895e2023744">
              <SHORT-NAME>FICMV2XEnEnbReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FICMV2XEnEnbReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4fbdda81c1f431b0a85ee0306800636c">
              <SHORT-NAME>FLDSP_FRWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDSP_FRWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9bcf8494f8a031ada845f6006dd3ca50">
              <SHORT-NAME>FLDSP_RLWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDSP_RLWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b718fc09d39731f2a91314935c1398c2">
              <SHORT-NAME>FLDSP_RRWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDSP_RRWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e7ef13fac483130be91c482e237a8b0">
              <SHORT-NAME>FLDSP_RrWinInhbSwtFlt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDSP_RrWinInhbSwtFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f1bb160a3c130459048c2a9f6d5e4d2">
              <SHORT-NAME>FLDSP_RrWinInhbSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDSP_RrWinInhbSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91b147b746e33393bd26c2b524132755">
              <SHORT-NAME>FLDircnLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d86361ff93a038d68a631cd7ac72a693">
              <SHORT-NAME>FLDircnLghtFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e68da14508b33afd8ce5164d093b10bc">
              <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4957582126a837d5af34fabe549e1bcb">
              <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDoorHndlPESwtActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d5539942a5e331469ce4b350f5a5934c">
              <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c66fe16d8f03f8b87ddbd6bb5f246b7">
              <SHORT-NAME>FLObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39f81a50a678364e87e42adc4217d75b">
              <SHORT-NAME>FLSLMMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSLMMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="881a9adfe0293113b91ab349d6b77626">
              <SHORT-NAME>FLSObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="607f09a8ae8936f68eb819e6718435bd">
              <SHORT-NAME>FLSUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db76af7b7f6035e8885e37f4cf48d647">
              <SHORT-NAME>FLSeatHeatCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatHeatCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7dfa89ea5ccf3a7b9ba2c78c0eace84c">
              <SHORT-NAME>FLSeatHorzPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatHorzPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e87bc4d62033a389a881ffb2f1091a3">
              <SHORT-NAME>FLSeatHoztMotActn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatHoztMotActn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c24bc20ab0963e06a6b32b9463becc13">
              <SHORT-NAME>FLSeatRclnMotActn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatRclnMotActn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="672e917fc5c6357fad4ceb46c8a0277d">
              <SHORT-NAME>FLSeatVentCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatVentCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b563b6b770523736801118bdb4a1b302">
              <SHORT-NAME>FLSeatVertMotActn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatVertMotActn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ea9f6d6706438dbaf761d396d12dfc3">
              <SHORT-NAME>FLSeatVertPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatVertPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6752c1d2dba63cfc942e1c8abd65fda2">
              <SHORT-NAME>FLSeatZeroSt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSeatZeroSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a1cb927c1b733eaa677fc007e648654">
              <SHORT-NAME>FLSideObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a12d95bbfe5436b385b5b204dbf1d7cf">
              <SHORT-NAME>FLSuperLckSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f54395d853523f97840e1f0ee670e38c">
              <SHORT-NAME>FLTirePrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="482d9f036f273a2981a529e78909222b">
              <SHORT-NAME>FLTirePrsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="992c3524ff1e345e95262b303fa1a2a3">
              <SHORT-NAME>FLTireSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7004e043b8df3e55aff3c06209dd00b7">
              <SHORT-NAME>FLTireTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="912d2a12c46a3c3fba546cdcf9ad791d">
              <SHORT-NAME>FLTireTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1211df2dc59232d4ad9380bb8ab3686b">
              <SHORT-NAME>FLUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ff0d76701b6f3c5aa8c94bc1de3a75cc">
              <SHORT-NAME>FLVntngMotPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLVntngMotPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f7f1561a4273a50b253fae659f52869">
              <SHORT-NAME>FLWinLclSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLWinLclSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="530154e457aa36e4b21158b20fa9452c">
              <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FLiDARPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="397e8861b14435209506f2f2cc25d15c">
              <SHORT-NAME>FMLUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FMLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9227d07f62433b89b4113583d733cd3a">
              <SHORT-NAME>FMOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FMOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ff4bb4534fd4377fbfadaca62e0f61f7">
              <SHORT-NAME>FMRUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FMRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7fc5d7b5016d3e6db4dbd0e8d412be28">
              <SHORT-NAME>FOTAStatus</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FOTAStatus</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="555393f6d32b335e965b66267a55c80e">
              <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FOTAStatusValid</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e054411bbfb93898839b3e891efd337f">
              <SHORT-NAME>FOTATarget</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FOTATarget</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="660bde79a6d035f9a221fce6b298d3ab">
              <SHORT-NAME>FOTATargetValid</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FOTATargetValid</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d47aef570fd93da6bcf571619ff7f215">
              <SHORT-NAME>FRDSP_FLWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDSP_FLWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="311daa3cabb93b559365888728f8a0e2">
              <SHORT-NAME>FRDSP_RLWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDSP_RLWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b00bb2eefa8c3db3bcd1f1be2956b12d">
              <SHORT-NAME>FRDSP_RRWinSwtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDSP_RRWinSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="983408b63295330cbfd3af39b8fa2824">
              <SHORT-NAME>FRDircnLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="27da9ee9940f3f28878b5f0e7e85bdd8">
              <SHORT-NAME>FRDircnLghtFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5b9fcbd247773cfe890a0ce3b2244ae0">
              <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7285bc64bf493e4dabd4b6c81f88fda2">
              <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDoorHndlPESwtActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6f3e29c2706b3ed29ef8627a9fa0ef69">
              <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="668c7eaa095639af96b2494a8f33d33c">
              <SHORT-NAME>FRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="be5540e1684833b5b6d075b233818cd6">
              <SHORT-NAME>FRSLMMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSLMMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="232d4442247a32a8a2db8c96865b8f94">
              <SHORT-NAME>FRSObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d08e8afe411839169eba8821992c1b70">
              <SHORT-NAME>FRSUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e531c982ecd43317906c806714b8f058">
              <SHORT-NAME>FRSeatHeatCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSeatHeatCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d15acbe764733279af320f8646951a35">
              <SHORT-NAME>FRSeatHorzPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSeatHorzPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8961db3cc27c316695a8eb62be63aa0e">
              <SHORT-NAME>FRSeatVentCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSeatVentCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a8912137e863f908c8bd564f93695f8">
              <SHORT-NAME>FRSeatVertPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSeatVertPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f2f4581f8b1035a4b003068070f4484a">
              <SHORT-NAME>FRSideObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c441d852b7233268a41ef8a9da05708">
              <SHORT-NAME>FRSuperLckSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="972a51c477d3384e949b6e453c3de74d">
              <SHORT-NAME>FRTirePrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f6b2ba33888e32d9bb4102ae9ee49ad2">
              <SHORT-NAME>FRTirePrsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5952b591ea8b34b29003a46706a77988">
              <SHORT-NAME>FRTireSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="549a3b966b493e08b6f9610549115212">
              <SHORT-NAME>FRTireTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="567782cf7ab23e34b71a9777d20808d1">
              <SHORT-NAME>FRTireTemV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91cfd359fc2e359c9845670a6e205b69">
              <SHORT-NAME>FRUSSSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d477b41e861f3985af480a4c3051f6a9">
              <SHORT-NAME>FRVntngMotPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRVntngMotPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae2011d9497636b19215c024d250ad7f">
              <SHORT-NAME>FRWinIninSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRWinIninSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de5e39367d5931cbb7e143f306562ef4">
              <SHORT-NAME>FRWinShrtDwnSucd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FRWinShrtDwnSucd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="68a7fd6b028a3c60b3323f182b7db1a5">
              <SHORT-NAME>FVCMAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3cc66d4aaa832b9852a95d1a91c15bf">
              <SHORT-NAME>FVCMPowerFailSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCMPowerFailSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e527a26e6c53aacab351894c63f8720">
              <SHORT-NAME>FVCMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a3955b5e63f3af58e3bd47fd23ee64d">
              <SHORT-NAME>FVCM_10ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0bf4a3c21860395cad59f6aa6ab72b9e">
              <SHORT-NAME>FVCM_10ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3611eb59245e346ebe10ee4f5e62b7e0">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d22c650580432cc9a65231a457c68e6">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b17a87334ce3f6fbbc92d6379ee65d2">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b79f2ef854853bf083192bee8e2f550f">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16a7605596b73776860946d790f20aae">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b3907b9ddc2437fc89cb01fbf16b3521">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2186e49223183327ac9b35a0cea5fafe">
              <SHORT-NAME>FVCM_10ms_Group01_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_10ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b5b77f82d2e3274a722f5139312e1bb">
              <SHORT-NAME>FVCM_20ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c989683615b3ce59dce87e5b00bc5c0">
              <SHORT-NAME>FVCM_20ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0653918041a63b379cff999f51245b13">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db8f2c94fd7f30adac89d5d0de2587c5">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62ddb172d39b3322b5267ade838cc9ef">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a7aac8a4df7347e95b870cc3b4907d6">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="210a14e90a873061adbeeaa1c6c79074">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="760e0ef976463341b7ddd92fed62164b">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="89988ef18672301a81738d997c1b06f7">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62fc2e425fee3dad90e36533c05eb135">
              <SHORT-NAME>FVCM_20ms_Group02_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FVCM_20ms_Group02_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b091398dbd4a3f2da07ac4abaf27ade7">
              <SHORT-NAME>FasnDrvrSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnDrvrSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a77798a60ec2396493509dac16fde342">
              <SHORT-NAME>FasnDrvrSbltIndCmdEvtTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnDrvrSbltIndCmdEvtTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64ab25dc3ffd307a877d30299580e056">
              <SHORT-NAME>FasnFrtPsngSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnFrtPsngSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6b4098aad3bf32378fc43642b4aebbaf">
              <SHORT-NAME>FasnFrtRowMidSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnFrtRowMidSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64a459140eae310ebe88a1708524075e">
              <SHORT-NAME>FasnFrtRowMidSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnFrtRowMidSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9a946ba002ea37e9aa7350f2252ec5a3">
              <SHORT-NAME>FasnFrtRowMidSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnFrtRowMidSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fae3d29006793e779aa8cee904195d39">
              <SHORT-NAME>FasnSbltAudRmndr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSbltAudRmndr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="07f3f430cce236bc83c1e80305121e85">
              <SHORT-NAME>FasnSecRowLSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowLSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d5747c614866335a966130b63946bba0">
              <SHORT-NAME>FasnSecRowLSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowLSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c09b1fbf6c539868fbda9e8bf9d13c9">
              <SHORT-NAME>FasnSecRowLSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowLSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b20a631104c13737bffc21d1105c5e08">
              <SHORT-NAME>FasnSecRowMidSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowMidSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="957de688f21e35e8989bdd8559c6f6b7">
              <SHORT-NAME>FasnSecRowMidSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowMidSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd07a2144c90375486140eeb429391c4">
              <SHORT-NAME>FasnSecRowMidSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowMidSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a6ea6a711c7e379b95f7498dca2df7d4">
              <SHORT-NAME>FasnSecRowRSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowRSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e555a9a799663605b0642a4692cd302c">
              <SHORT-NAME>FasnSecRowRSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowRSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7de22d631b513216943bf8f5bfd7d9b7">
              <SHORT-NAME>FasnSecRowRSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnSecRowRSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="45f2c8e928f037359e52822d6b584e07">
              <SHORT-NAME>FasnThrdRowLSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowLSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="34ae1f9cbe7c3b07b2d6da1613cac12b">
              <SHORT-NAME>FasnThrdRowLSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowLSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cce8ad9519fe3a3495757437a391bb3c">
              <SHORT-NAME>FasnThrdRowLSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowLSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="751b3ece4359361fb6e7374b2679d760">
              <SHORT-NAME>FasnThrdRowMidSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowMidSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93fe9daa95483cf585269af97043abd1">
              <SHORT-NAME>FasnThrdRowMidSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowMidSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1989d5bd1ad3baab28db792a9a0608f">
              <SHORT-NAME>FasnThrdRowMidSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowMidSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e9e10def7dfd3a78b4987c111b63ff15">
              <SHORT-NAME>FasnThrdRowRSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowRSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="751b1bf0af99349aaa755891841babbf">
              <SHORT-NAME>FasnThrdRowRSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowRSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0013de2e65093e1293f4b4aac9f644e1">
              <SHORT-NAME>FasnThrdRowRSbltIndCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FasnThrdRowRSbltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4a317da45c7a36229330fe6cb26f55c0">
              <SHORT-NAME>FindCarFuncInfoDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FindCarFuncInfoDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51d902ed09ba3b4a99f0d28267539416">
              <SHORT-NAME>FixType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FixType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aae0ee4f9ef035dd82a5332a7f163a23">
              <SHORT-NAME>FlbStrgFnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FlbStrgFnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a1cb67afc600368e89867d788410f4ee">
              <SHORT-NAME>FlbStrgFnStsResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FlbStrgFnStsResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="26684bdfe3b63145ae1198cfdb9fbca8">
              <SHORT-NAME>FllwMeReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FllwMeReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f83601eaaf2c34d3bd2ea8656f003bbb">
              <SHORT-NAME>FollowMeHomeReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FollowMeHomeReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9dc85df0150e353288478b480cd6f93f">
              <SHORT-NAME>FollowMeHomeReq_LHZCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FollowMeHomeReq_LHZCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9fef6cd3cc603362ac150963b39f8069">
              <SHORT-NAME>FrSsdAntiPnchSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdAntiPnchSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="459415b901b538f68d0ad312137f35c5">
              <SHORT-NAME>FrSsdHallErrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdHallErrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b970d5d241823fe990b273483c52bbea">
              <SHORT-NAME>FrSsdInitSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdInitSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a104759c21831bf80a807549c9b4417">
              <SHORT-NAME>FrSsdLrngFailRrsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdLrngFailRrsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="512afac920bb302dac27a1a46dbfbc7f">
              <SHORT-NAME>FrSsdLrngSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdLrngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d0ca8e50477359da139c136530517d2">
              <SHORT-NAME>FrSsdManuCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdManuCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3131540a32e53596ba5ec4a72f92911c">
              <SHORT-NAME>FrSsdMotRlyFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdMotRlyFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9579d2e559763f7194882fefa6de0373">
              <SHORT-NAME>FrSsdMotSledSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdMotSledSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba2fbc1d87213139b844832a19c54ad7">
              <SHORT-NAME>FrSsdMotThrmlProtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdMotThrmlProtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63961702f2443d409d408beeaf6078c4">
              <SHORT-NAME>FrSsdMotVolErrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdMotVolErrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab07cb4a1a033b2a95eec70e553f0781">
              <SHORT-NAME>FrSsdMovSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrSsdMovSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20608e72da283b6d968d0a1c858c69e7">
              <SHORT-NAME>FrtAxleActuWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtAxleActuWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="efbf55ed4db33147a621487314bafa9a">
              <SHORT-NAME>FrtAxleActuWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtAxleActuWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d336d5928e5d3946a5a3e27f3b793a4f">
              <SHORT-NAME>FrtBmpAntFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtBmpAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2631d764c76b3252ac38831e4c206485">
              <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtCamrHeatCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b374751b089a31bf9081ecd829b9e645">
              <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtCamrHeatSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c088464b028e3b62b8768127e5d310fe">
              <SHORT-NAME>FrtCarGoNotfr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtCarGoNotfr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8ed6f9876a823d1c83ffd322d0cfa918">
              <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtCarGoNotfrDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="38ebbb5b1c8f3fb49725b9ca58a346c8">
              <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtCarGoNotfrSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1307474a2e230669dcc60f31b1f5ce1">
              <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtMidLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c602cf636bdd38da9a79a6cde9fb757b">
              <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtMidRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0125c07a7db23c96b7a18b0c75b68820">
              <SHORT-NAME>FrtObsDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtObsDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1de82a4384b53a29a59ac5331487df41">
              <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPDCAudWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51f7f0b8b2433868ab248c847fda37d5">
              <SHORT-NAME>FrtPDCPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPDCPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d64e26e2951355d98c23e56399156d4">
              <SHORT-NAME>FrtPsngAirbagDsblIndF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagDsblIndF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="663e8f9b94c93885b0b2927d32f89262">
              <SHORT-NAME>FrtPsngAirbagEnbIndF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagEnbIndF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c2e339ad10863af9a792dcea897ebd32">
              <SHORT-NAME>FrtPsngAirbagIndReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagIndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="996c1f9e64203c788b79456b99ff0c54">
              <SHORT-NAME>FrtPsngAirbagSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="36808b18cffc328a824f760100107a53">
              <SHORT-NAME>FrtPsngAirbagSwStsReqV_Sfty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagSwStsReqV_Sfty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b9b5d2c4b0d3973be4123f76ebe9b61">
              <SHORT-NAME>FrtPsngAirbagSwStsReq_Sfty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngAirbagSwStsReq_Sfty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="832258e01c9939d09a853d1432f7814c">
              <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngDoorOpenSts_LHZCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e77cdb67523031ccbd5ef1371591da6d">
              <SHORT-NAME>FrtPsngOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="497f33c7b6953c59835e7be8fad976d8">
              <SHORT-NAME>FrtPsngSbltAtc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngSbltAtc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef7c087d6faa3d89a77dc914f14c47e3">
              <SHORT-NAME>FrtPsngSbltAtcV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPsngSbltAtcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b352407bd393371b640bd9c5675ef88">
              <SHORT-NAME>FrtPwrSktPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtPwrSktPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a46b36ca4c5d38ff89c131e40fe58934">
              <SHORT-NAME>FrtSDAPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtSDAPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f363f6fb689374d8a7ad3d8cc6d4953">
              <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtTireStdPrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c4932676e8763c839dda7e73f07ac771">
              <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWindShldSfcTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f90af80f197d32879485685ddd8a86fe">
              <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWindShldSurndHmdty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="10a49f037a0838a8bffe7a8a101df4b9">
              <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWindShldSurndTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b368c7d50ec35199d1feefa35821816">
              <SHORT-NAME>FrtWiperOpReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWiperOpReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="35ff2e8de71f3bab9177de633c99bfa6">
              <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWiperSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ffe1e76db8523f629eacca034227a17a">
              <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWiperSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4edea5b66e5d35a888178776eadb9bdc">
              <SHORT-NAME>FrtWshrPumpA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrtWshrPumpA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d854e94f50730aba442f265f05cea2f">
              <SHORT-NAME>FrwlLghtReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrwlLghtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ff1e60a76d939e6ac6bc894f8195a93">
              <SHORT-NAME>FrwlLghtReq_LHZCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FrwlLghtReq_LHZCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="decb8a14770831c1bf6c22ccf94a2b66">
              <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FuCutReq_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="34387fc1c99e35109fc0d4b0fbfc3d85">
              <SHORT-NAME>FuelCsump</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FuelCsump</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1e8c4c6a70a34f3b569dfb7968cd158">
              <SHORT-NAME>FuelSysVentCmdd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FuelSysVentCmdd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bfbec0ecfb63eeeaa576e21a24184c0">
              <SHORT-NAME>FuelSysVentFltA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FuelSysVentFltA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="168b82698bfb31df8248fc9a9ffd70a9">
              <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FulCutDMFPrdtn_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="30c9e7d388143650bbe3008cdcc7184f">
              <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FulCutEngStall_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61d00554dede3faabace99d5e62c4d32">
              <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/FulCutLosCommWthEMS_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf8b35914f69351688aa50be7d5771cd">
              <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSAntennasBroken</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="07b07c79f6fb30d0ac8fc1ed5f7d0ec5">
              <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSAntennasInfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48aa22d23e323bd292b5f038f881a614">
              <SHORT-NAME>GNSSF9HCounter</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSF9HCounter</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a714c06372e3a988aca367a113bbcde">
              <SHORT-NAME>GNSSSeq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSSeq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cbf735894e3b33229e97dbe9f0e53aed">
              <SHORT-NAME>GNSSUTCTime</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSUTCTime</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0afbd6e5d1313bf99e6cd7545501a1e0">
              <SHORT-NAME>GNSSUTCTimeH</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GNSSUTCTimeH</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ebdddb1d0115350da0d25ddf43c7cb88">
              <SHORT-NAME>GenrExctnCrnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GenrExctnCrnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78d2be0aa51932da9df476d9812eae7d">
              <SHORT-NAME>GenrExctnDutyCyc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/GenrExctnDutyCyc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c96eb27420531d4a5284a97b2db6da2">
              <SHORT-NAME>HBAActiveSt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HBAActiveSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="373a1f2eb4d932e682e50d00f4013b12">
              <SHORT-NAME>HBAValidSt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HBAValidSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d044eff8511b3221a51065ad2fbec272">
              <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HCUSAMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc42f7f80b363916bef3b77544e364f3">
              <SHORT-NAME>HDCReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HDCReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="787abc405b5c3467968c3be657f52b14">
              <SHORT-NAME>HDCSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HDCSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6eb84f57edd73d2cb0541e39b7df0910">
              <SHORT-NAME>HMISafFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HMISafFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2024d19bb5df31d8827622b031d65570">
              <SHORT-NAME>HODMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HODMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="baba9337096e3ff0937b6196814ae337">
              <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HORWarningEvtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c5922d893c23ec4bf6e0e3a481ad0dd">
              <SHORT-NAME>HPPFnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HPPFnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a8df95c0947738d7829c3faca57ef0bf">
              <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HPPInBmtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="28decde323ce3ae4a8859f7965c7b8b9">
              <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HPPMapBuildSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6e4762d7c43a3fbea5b524ee06dc11fe">
              <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HPPOnRoutSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aff3626e300836b0b371d062cb030869">
              <SHORT-NAME>HUDFwdLkngAmbtLghtLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HUDFwdLkngAmbtLghtLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d81942a9f773c9f8ec5d7a0651e1a3c">
              <SHORT-NAME>HUDLghtSnsrHdwrFltPrst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HUDLghtSnsrHdwrFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="23fc3ccda0ce354caaf85120df2a4372">
              <SHORT-NAME>HUDLkngAmbtLghtLvlByLux</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HUDLkngAmbtLghtLvlByLux</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="12b3f444612235ba8f2c6143d9cd85fc">
              <SHORT-NAME>HUDRLSAmbtLghtLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HUDRLSAmbtLghtLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9ef3d13ad643c9bbf4dbd63da1aee81">
              <SHORT-NAME>HVBatSOCHiRes</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVBatSOCHiRes</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="19d605eca0373da49b49acea95661c8d">
              <SHORT-NAME>HVBatSOCHiResV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVBatSOCHiResV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8affc2c02d132a8ad40ca97f6dffc2f">
              <SHORT-NAME>HVBatSOCMin</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVBatSOCMin</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a407545d94731fa9ae1043fd45c086d">
              <SHORT-NAME>HVBatSOCTrgtHiRes</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVBatSOCTrgtHiRes</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8703bd91f3b3f33b79209efd9d032f2">
              <SHORT-NAME>HVBatShutOff</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVBatShutOff</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e58715fbbb2b3d9cba2eb85ea7fb1954">
              <SHORT-NAME>HVDCDCClntPumpPWMReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCDCClntPumpPWMReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="23ced1cd55f6376f80c27fc47ad111e5">
              <SHORT-NAME>HVDCDCHdwrFlr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCDCHdwrFlr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96cc344811d53334a5aa6b8da75ddab3">
              <SHORT-NAME>HVDCDCIntnlFlr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCDCIntnlFlr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65817ee7a77431d4a3814459c1097b61">
              <SHORT-NAME>HVDCDCSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCDCSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b4cdb1ba19e3dba94742a2f73806c36">
              <SHORT-NAME>HVDCDCTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCDCTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46b7f260963d39089064a879376bc753">
              <SHORT-NAME>HVDCHVILSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCHVILSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f234b25e2a6e3c419aeed8532ade723d">
              <SHORT-NAME>HVDCHVILStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HVDCHVILStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b68f0d0057463be7aadec62e30628c66">
              <SHORT-NAME>HWPEMSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HWPEMSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b79d3c918e8382d87aadcab400ba8e9">
              <SHORT-NAME>HWPEMStsForEdr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HWPEMStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf67a05898f7350ca40d79252e5a45ab">
              <SHORT-NAME>HandOffStrgWhlDetnSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HandOffStrgWhlDetnSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="76a04b72fd4e34459eba2c2f68930173">
              <SHORT-NAME>HandOffStrgWhlDetnStaV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HandOffStrgWhlDetnStaV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0cad0199e00035c0ad4c93865817a415">
              <SHORT-NAME>Hdop</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Hdop</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed21da139107307d8560c892f5122ddb">
              <SHORT-NAME>HeadingRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HeadingRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da9257ca61963780a9b7db8d5a79a1cd">
              <SHORT-NAME>HeadingSigma</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HeadingSigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="60022f363c233735850a0168169f0a2a">
              <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HmdtySnsrHdwrFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="678de2c3783a324faaf6863f034efaf7">
              <SHORT-NAME>HtdFrtLftVwWndActSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HtdFrtLftVwWndActSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="650115c9a5bd390b8b58597073163c17">
              <SHORT-NAME>HybAPAAvlbl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HybAPAAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4dc5b9c294343d1388252139a1f6e01e">
              <SHORT-NAME>HybEnSpdReqF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HybEnSpdReqF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a2b04cc6a3532e1aac22f7989e5ea9d">
              <SHORT-NAME>HybEnStSpOvrd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HybEnStSpOvrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4cf47375185d36d3a542b8434639ee7e">
              <SHORT-NAME>HzrdLampsCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HzrdLampsCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="662ad683994e3fff9aa168322ce4b311">
              <SHORT-NAME>HzrdLghtSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/HzrdLghtSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fe6a74cb825f38c6bd49e206ede7fafc">
              <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IACCOvTSuppresCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="50a9873d37d43b18a2d493fe16a54d0e">
              <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IACCOvTSuppresSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8115ae16e825311dad84a69dd8f55fb8">
              <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IACCPreMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0de8a2a0b3933450909a5934f6a2414f">
              <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IACCPreSpdLimtCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5cc3bb61997b3b90af520b4c990ff695">
              <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IACCPreSpdLimtSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e79a03e3f7663d5988a315f29f423f66">
              <SHORT-NAME>IAMAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa400156950f30d8885fc85c277caeb8">
              <SHORT-NAME>IAMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a65cc3b20f5233c9bcfa59afaa772c68">
              <SHORT-NAME>IAMReststs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAMReststs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3110394d343136db92412ebac4154e9f">
              <SHORT-NAME>IAM_100ms_Group08_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group08_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5cd76d60e3be3db592ec862c3365e8f2">
              <SHORT-NAME>IAM_100ms_Group08_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group08_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cccc331ddcb23526a4df23090f198665">
              <SHORT-NAME>IAM_100ms_Group08_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group08_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13c0c3bec3c834be9d854edd5aec8567">
              <SHORT-NAME>IAM_100ms_Group18_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group18_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f2aa13a84e6630ae9412e0cdf7b5f343">
              <SHORT-NAME>IAM_100ms_Group18_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group18_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64c9f8759b02326986256be5a0b3337f">
              <SHORT-NAME>IAM_100ms_Group18_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group18_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31504fff8f223834b81d1078d6b87190">
              <SHORT-NAME>IAM_100ms_Group56_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group56_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3978eebc571f3266bf674cbdd8a037cf">
              <SHORT-NAME>IAM_100ms_Group56_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group56_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e84ec24acfd430bfbf67e999cba3a36d">
              <SHORT-NAME>IAM_100ms_Group56_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group56_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57001c585db63c67a6933d8b5484dd3f">
              <SHORT-NAME>IAM_100ms_Group56_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_100ms_Group56_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6526a309ee913287b0891cfad28b0b5a">
              <SHORT-NAME>IAM_20ms_Group32_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82f6c68dc025365988ea25a9a00273b5">
              <SHORT-NAME>IAM_20ms_Group32_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="45fe635378b93632a96fdb6b7aa94aca">
              <SHORT-NAME>IAM_20ms_Group32_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cae889204d6a364189631eae2d3a5fb0">
              <SHORT-NAME>IAM_20ms_Group32_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4a811b9af0df313293f59d461b463669">
              <SHORT-NAME>IAM_20ms_Group32_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="97a11bc2202b3b05876e1f436443fe1a">
              <SHORT-NAME>IAM_20ms_Group32_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="114dcb6a6fcc3caca319e48f1638d5f5">
              <SHORT-NAME>IAM_20ms_Group32_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8dd758960523db9b9ef7929acc303ef">
              <SHORT-NAME>IAM_20ms_Group32_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51786b58b9d53b7f824651b602d82b27">
              <SHORT-NAME>IAM_20ms_Group32_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e572b8e2500e304db04078b168ec07cf">
              <SHORT-NAME>IAM_20ms_Group32_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbf5dd2f879a3eef98c0a84176b146d8">
              <SHORT-NAME>IAM_20ms_Group32_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="90c89a23444c3b3a8aaab334e85396de">
              <SHORT-NAME>IAM_20ms_Group32_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_20ms_Group32_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24820c075e983d0b8aebb61b1f56dfd8">
              <SHORT-NAME>IAM_GNSS_Signal_Status</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_GNSS_Signal_Status</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f08d4bb43bd93a40a2920cc7397d2a20">
              <SHORT-NAME>IAM_ZONE_100ms_Group13_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
