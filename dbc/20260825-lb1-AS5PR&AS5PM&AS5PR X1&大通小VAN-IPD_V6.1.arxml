                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FulCutEngStall_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111411XOa505a3f19f25843c4b11141000">
              <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11141cXOa505a3f19f25843c4b11141b00">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FulCutLosCommWthEMS_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bb6fXOa505a3f19f25843c4b10bb6e00">
              <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb7aXOa505a3f19f25843c4b10bb7900">
                  <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/GNSSAntennasBroken</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bb86XOa505a3f19f25843c4b10bb8500">
              <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb91XOa505a3f19f25843c4b10bb9000">
                  <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/GNSSAntennasInfo</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111428XOa505a3f19f25843c4b11142700">
              <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111433XOa505a3f19f25843c4b11143200">
                  <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HCUSAMTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b122648XOa505a3f19f25843c4b12264700">
              <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b122653XOa505a3f19f25843c4b12265200">
                  <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HORWarningEvtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb58XOa505a3f19f25843c4b10fb5700">
              <SHORT-NAME>HPPFnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb63XOa505a3f19f25843c4b10fb6200">
                  <SHORT-NAME>HPPFnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HPPFnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb9dXOa505a3f19f25843c4b10fb9c00">
              <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fba8XOa505a3f19f25843c4b10fba700">
                  <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HPPInBmtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb6fXOa505a3f19f25843c4b10fb6e00">
              <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb7aXOa505a3f19f25843c4b10fb7900">
                  <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HPPMapBuildSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb86XOa505a3f19f25843c4b10fb8500">
              <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb91XOa505a3f19f25843c4b10fb9000">
                  <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HPPOnRoutSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11bc64XOa505a3f19f25843c4b11bc6300">
              <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11bc6fXOa505a3f19f25843c4b11bc6e00">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/HmdtySnsrHdwrFltPrst</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c532XOa505a3f19f25843c4b11c53100">
              <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c53dXOa505a3f19f25843c4b11c53c00">
                  <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IACCOvTSuppresCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119b76XOa505a3f19f25843c4b119b7500">
              <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119b81XOa505a3f19f25843c4b119b8000">
                  <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IACCOvTSuppresSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c51bXOa505a3f19f25843c4b11c51a00">
              <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c526XOa505a3f19f25843c4b11c52500">
                  <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IACCPreMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c504XOa505a3f19f25843c4b11c50300">
              <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c50fXOa505a3f19f25843c4b11c50e00">
                  <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IACCPreSpdLimtCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119b5fXOa505a3f19f25843c4b119b5e00">
              <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119b6aXOa505a3f19f25843c4b119b6900">
                  <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IACCPreSpdLimtSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109e16XOa505a3f19f25843c4b109e1500">
              <SHORT-NAME>IAMAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109e21XOa505a3f19f25843c4b109e2000">
                  <SHORT-NAME>IAMAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IAMAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ba89XOa505a3f19f25843c4b10ba8800">
              <SHORT-NAME>IAMReststs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ba94XOa505a3f19f25843c4b10ba9300">
                  <SHORT-NAME>IAMReststs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IAMReststs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbafb42XNa505a3f19f34f4acdbafb3c00">
              <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbafb50XNa505a3f19f34f4acdbafb4a00">
                  <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb18c2XNa505a3f19f34f4acdbb18bc00">
              <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb18cfXNa505a3f19f34f4acdbb18c900">
                  <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb1a3dXNa505a3f19f34f4acdbb1a3700">
              <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb1a4aXNa505a3f19f34f4acdbb1a4400">
                  <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102d34XOa505a3f19f25843c4b102d3300">
              <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102d3fXOa505a3f19f25843c4b102d3e00">
                  <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb1305XNa505a3f19f34f4acdbb12ff00">
              <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb1312XNa505a3f19f34f4acdbb130c00">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb16f2XNa505a3f19f34f4acdbb16ec00">
              <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb16ffXNa505a3f19f34f4acdbb16f900">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb1480XNa505a3f19f34f4acdbb147a00">
              <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb148dXNa505a3f19f34f4acdbb148700">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbafcc0XNa505a3f19f34f4acdbafcba00">
              <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbafccdXNa505a3f19f34f4acdbafcc700">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb1eb7XNa505a3f19f34f4acdbb1eb100">
              <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb1ec4XNa505a3f19f34f4acdbb1ebe00">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102053XOa505a3f19f25843c4b10205200">
              <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10205eXOa505a3f19f25843c4b10205d00">
                  <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1020f4XOa505a3f19f25843c4b1020f300">
              <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1020ffXOa505a3f19f25843c4b1020fe00">
                  <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10210bXOa505a3f19f25843c4b10210a00">
              <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102116XOa505a3f19f25843c4b10211500">
                  <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10200cXOa505a3f19f25843c4b10200b00">
              <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102018XOa505a3f19f25843c4b10201700">
                  <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101fdeXOa505a3f19f25843c4b101fdd00">
              <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b101fe9XOa505a3f19f25843c4b101fe800">
                  <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10203cXOa505a3f19f25843c4b10203b00">
              <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102047XOa505a3f19f25843c4b10204600">
                  <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102122XOa505a3f19f25843c4b10212100">
              <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10212eXOa505a3f19f25843c4b10212d00">
                  <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101ff5XOa505a3f19f25843c4b101ff400">
              <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102000XOa505a3f19f25843c4b101fff00">
                  <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10213bXOa505a3f19f25843c4b10213a00">
              <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102146XOa505a3f19f25843c4b10214500">
                  <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102152XOa505a3f19f25843c4b10215100">
              <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10215eXOa505a3f19f25843c4b10215d00">
                  <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102025XOa505a3f19f25843c4b10202400">
              <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102030XOa505a3f19f25843c4b10202f00">
                  <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109ee5XOa505a3f19f25843c4b109ee400">
              <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109ef0XOa505a3f19f25843c4b109eef00">
                  <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IBS_CHAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1021b0XOa505a3f19f25843c4b1021af00">
              <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1021bbXOa505a3f19f25843c4b1021ba00">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10318dXOa505a3f19f25843c4b10318c00">
              <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103198XOa505a3f19f25843c4b10319700">
                  <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102fa3XOa505a3f19f25843c4b102fa200">
              <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102faeXOa505a3f19f25843c4b102fad00">
                  <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10254aXOa505a3f19f25843c4b10254900">
              <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102555XOa505a3f19f25843c4b10255400">
                  <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10244dXOa505a3f19f25843c4b10244c00">
              <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102458XOa505a3f19f25843c4b10245700">
                  <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10251cXOa505a3f19f25843c4b10251b00">
              <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102527XOa505a3f19f25843c4b10252600">
                  <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10305bXOa505a3f19f25843c4b10305a00">
              <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103066XOa505a3f19f25843c4b10306500">
                  <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102464XOa505a3f19f25843c4b10246300">
              <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10246fXOa505a3f19f25843c4b10246e00">
                  <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10241fXOa505a3f19f25843c4b10241e00">
              <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10242aXOa505a3f19f25843c4b10242900">
                  <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102927XOa505a3f19f25843c4b10292600">
              <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102932XOa505a3f19f25843c4b10293100">
                  <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102533XOa505a3f19f25843c4b10253200">
              <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10253eXOa505a3f19f25843c4b10253d00">
                  <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10258fXOa505a3f19f25843c4b10258e00">
              <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10259aXOa505a3f19f25843c4b10259900">
                  <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1025a6XOa505a3f19f25843c4b1025a500">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1025b1XOa505a3f19f25843c4b1025b000">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1025bdXOa505a3f19f25843c4b1025bc00">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1025c8XOa505a3f19f25843c4b1025c700">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbafe3bXNa505a3f19f34f4acdbafe3500">
              <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbafe48XNa505a3f19f34f4acdbafe4200">
                  <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f34f4acdbb069eXNa505a3f19f34f4acdbb069800">
              <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f34f4acdbb06abXNa505a3f19f34f4acdbb06a500">
                  <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102505XOa505a3f19f25843c4b10250400">
              <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102510XOa505a3f19f25843c4b10250f00">
                  <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102492XOa505a3f19f25843c4b10249100">
              <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10249dXOa505a3f19f25843c4b10249c00">
                  <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102408XOa505a3f19f25843c4b10240700">
              <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102413XOa505a3f19f25843c4b10241200">
                  <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102cc1XOa505a3f19f25843c4b102cc000">
              <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102cccXOa505a3f19f25843c4b102ccb00">
                  <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10302dXOa505a3f19f25843c4b10302c00">
              <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103038XOa505a3f19f25843c4b10303700">
                  <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102caaXOa505a3f19f25843c4b102ca900">
              <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102cb5XOa505a3f19f25843c4b102cb400">
                  <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102d1dXOa505a3f19f25843c4b102d1c00">
              <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102d28XOa505a3f19f25843c4b102d2700">
                  <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dfb3XOa505a3f19f25843c4b11dfb200">
              <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dfbeXOa505a3f19f25843c4b11dfbd00">
                  <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMDrvrDstcnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dfcaXOa505a3f19f25843c4b11dfc900">
              <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dfd5XOa505a3f19f25843c4b11dfd400">
                  <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMDrvrFtgLvl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dfe1XOa505a3f19f25843c4b11dfe000">
              <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dfecXOa505a3f19f25843c4b11dfeb00">
                  <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMDrvrPrst</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dff8XOa505a3f19f25843c4b11dff700">
              <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11e003XOa505a3f19f25843c4b11e00200">
                  <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMEyeOnRoad</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f3a1b413220dcfXNa505a3f19f3a1b413220dc900">
              <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f3a1b413220ddcXNa505a3f19f3a1b413220dd600">
                  <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMSwReq_Reserve16</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f3a1b413220f22XNa505a3f19f3a1b413220f1c00">
              <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f3a1b413220f2fXNa505a3f19f3a1b413220f2900">
                  <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ICMSwReq_Reserve17</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1088e2XOa505a3f19f25843c4b1088e100">
              <SHORT-NAME>ILCSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1088edXOa505a3f19f25843c4b1088ec00">
                  <SHORT-NAME>ILCSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ILCSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b103115XOa505a3f19f25843c4b10311400">
              <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103121XOa505a3f19f25843c4b10312000">
                  <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b114a83XOa505a3f19f25843c4b114a8200">
              <SHORT-NAME>IMU_SN</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b114a8eXOa505a3f19f25843c4b114a8d00">
                  <SHORT-NAME>IMU_SN</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-ARRAY-DATA-TYPE">/DataTypes/ApplicationDataTypes/IMU_SN</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b115f42XOa505a3f19f25843c4b115f4100">
              <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b115f4dXOa505a3f19f25843c4b115f4c00">
                  <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDAVCamrHeatReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e2e8XOa505a3f19f25843c4b10e2e700">
              <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e2f3XOa505a3f19f25843c4b10e2f200">
                  <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDAlgFlag</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ce6cXOa505a3f19f25843c4b10ce6b00">
              <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ce77XOa505a3f19f25843c4b10ce7600">
                  <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDAurixTemp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e161XOa505a3f19f25843c4b10e16000">
              <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e16cXOa505a3f19f25843c4b10e16b00">
                  <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDComKeyEnbResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e247XOa505a3f19f25843c4b10e24600">
              <SHORT-NAME>IPDDataId</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e252XOa505a3f19f25843c4b10e25100">
                  <SHORT-NAME>IPDDataId</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDDataId</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e2a3XOa505a3f19f25843c4b10e2a200">
              <SHORT-NAME>IPDErrorCount</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e2aeXOa505a3f19f25843c4b10e2ad00">
                  <SHORT-NAME>IPDErrorCount</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDErrorCount</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e25eXOa505a3f19f25843c4b10e25d00">
              <SHORT-NAME>IPDFailedReason</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e269XOa505a3f19f25843c4b10e26800">
                  <SHORT-NAME>IPDFailedReason</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDFailedReason</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e092XOa505a3f19f25843c4b10e09100">
              <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e09dXOa505a3f19f25843c4b10e09c00">
                  <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDIdentityResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e2d1XOa505a3f19f25843c4b10e2d000">
              <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e2dcXOa505a3f19f25843c4b10e2db00">
                  <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDKeyStatus</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ff07XOa505a3f19f25843c4b10ff0600">
              <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ff12XOa505a3f19f25843c4b10ff1100">
                  <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDMCUTemp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ce9aXOa505a3f19f25843c4b10ce9900">
              <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cea5XOa505a3f19f25843c4b10cea400">
                  <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDPCBTemp1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ceb1XOa505a3f19f25843c4b10ceb000">
              <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cebcXOa505a3f19f25843c4b10cebb00">
                  <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDPCBTemp2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cec8XOa505a3f19f25843c4b10cec700">
              <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ced3XOa505a3f19f25843c4b10ced200">
                  <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDPMICTemp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fec2XOa505a3f19f25843c4b10fec100">
              <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fecdXOa505a3f19f25843c4b10fecc00">
                  <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDPowerFailSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e275XOa505a3f19f25843c4b10e27400">
              <SHORT-NAME>IPDResetCnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e280XOa505a3f19f25843c4b10e27f00">
                  <SHORT-NAME>IPDResetCnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDResetCnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ce83XOa505a3f19f25843c4b10ce8200">
              <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ce8eXOa505a3f19f25843c4b10ce8d00">
                  <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDSOCTemp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cedfXOa505a3f19f25843c4b10cede00">
              <SHORT-NAME>IPDStsResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ceeaXOa505a3f19f25843c4b10cee900">
                  <SHORT-NAME>IPDStsResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDStsResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cef6XOa505a3f19f25843c4b10cef500">
              <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf01XOa505a3f19f25843c4b10cf0000">
                  <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDThermalWrnngLvl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e28cXOa505a3f19f25843c4b10e28b00">
              <SHORT-NAME>IPDTripCnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e297XOa505a3f19f25843c4b10e29600">
                  <SHORT-NAME>IPDTripCnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDTripCnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e105XOa505a3f19f25843c4b10e10400">
              <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e110XOa505a3f19f25843c4b10e10f00">
                  <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDTripCntResetResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e2baXOa505a3f19f25843c4b10e2b900">
              <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e2c5XOa505a3f19f25843c4b10e2c400">
                  <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDTripNvmTag</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cf0dXOa505a3f19f25843c4b10cf0c00">
              <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf18XOa505a3f19f25843c4b10cf1700">
                  <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDWtrClntInltFlwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ff1eXOa505a3f19f25843c4b10ff1d00">
              <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ff29XOa505a3f19f25843c4b10ff2800">
                  <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDWtrClntInltReqFlg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cf24XOa505a3f19f25843c4b10cf2300">
              <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf2fXOa505a3f19f25843c4b10cf2e00">
                  <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPDWtrClntInltTimeReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102f5eXOa505a3f19f25843c4b102f5d00">
              <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102f69XOa505a3f19f25843c4b102f6800">
                  <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102f8cXOa505a3f19f25843c4b102f8b00">
              <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102f97XOa505a3f19f25843c4b102f9600">
                  <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102ee9XOa505a3f19f25843c4b102ee800">
              <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102ef4XOa505a3f19f25843c4b102ef300">
                  <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1031bbXOa505a3f19f25843c4b1031ba00">
              <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1031c6XOa505a3f19f25843c4b1031c500">
                  <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102d4bXOa505a3f19f25843c4b102d4a00">
              <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102d56XOa505a3f19f25843c4b102d5500">
                  <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1028e2XOa505a3f19f25843c4b1028e100">
              <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1028edXOa505a3f19f25843c4b1028ec00">
                  <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a180XOa505a3f19f25843c4b10a17f00">
              <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a18bXOa505a3f19f25843c4b10a18a00">
                  <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NKI_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a477XOa505a3f19f25843c4b10a47600">
              <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a482XOa505a3f19f25843c4b10a48100">
                  <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NKI_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a37aXOa505a3f19f25843c4b10a37900">
              <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a385XOa505a3f19f25843c4b10a38400">
                  <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NKI_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b112f1cXOa505a3f19f25843c4b112f1b00">
              <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b112f27XOa505a3f19f25843c4b112f2600">
                  <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NKI_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a4a5XOa505a3f19f25843c4b10a4a400">
              <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a4b0XOa505a3f19f25843c4b10a4af00">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_BSMtoRMS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a3a8XOa505a3f19f25843c4b10a3a700">
              <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a3b3XOa505a3f19f25843c4b10a3b200">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_BSMtoRMS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a2abXOa505a3f19f25843c4b10a2aa00">
              <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a2b6XOa505a3f19f25843c4b10a2b500">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_BSMtoRMS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1144daXOa505a3f19f25843c4b1144d900">
              <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1144e5XOa505a3f19f25843c4b1144e400">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_BSMtoRMS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a4bcXOa505a3f19f25843c4b10a4bb00">
              <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a4c7XOa505a3f19f25843c4b10a4c600">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOSSta_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a3bfXOa505a3f19f25843c4b10a3be00">
              <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a3caXOa505a3f19f25843c4b10a3c900">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOSSta_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a2c2XOa505a3f19f25843c4b10a2c100">
              <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a2cdXOa505a3f19f25843c4b10a2cc00">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOSSta_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1144f1XOa505a3f19f25843c4b1144f000">
              <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1144fcXOa505a3f19f25843c4b1144fb00">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOSSta_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a0dfXOa505a3f19f25843c4b10a0de00">
              <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a0eaXOa505a3f19f25843c4b10a0e900">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOStoRMS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a3d6XOa505a3f19f25843c4b10a3d500">
              <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a3e1XOa505a3f19f25843c4b10a3e000">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOStoRMS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a2d9XOa505a3f19f25843c4b10a2d800">
              <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a2e4XOa505a3f19f25843c4b10a2e300">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOStoRMS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b114508XOa505a3f19f25843c4b11450700">
              <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b114513XOa505a3f19f25843c4b11451200">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_NOStoRMS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a0f6XOa505a3f19f25843c4b10a0f500">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a101XOa505a3f19f25843c4b10a10000">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_PBSMtoRMS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a3edXOa505a3f19f25843c4b10a3ec00">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a3f8XOa505a3f19f25843c4b10a3f700">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_PBSMtoRMS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a2f0XOa505a3f19f25843c4b10a2ef00">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a2fbXOa505a3f19f25843c4b10a2fa00">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_PBSMtoRMS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11451fXOa505a3f19f25843c4b11451e00">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11452aXOa505a3f19f25843c4b11452900">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_PBSMtoRMS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a10dXOa505a3f19f25843c4b10a10c00">
              <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a118XOa505a3f19f25843c4b10a11700">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMSSta_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a404XOa505a3f19f25843c4b10a40300">
              <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a40fXOa505a3f19f25843c4b10a40e00">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMSSta_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a307XOa505a3f19f25843c4b10a30600">
              <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a312XOa505a3f19f25843c4b10a31100">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMSSta_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b114536XOa505a3f19f25843c4b11453500">
              <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b114541XOa505a3f19f25843c4b11454000">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMSSta_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a124XOa505a3f19f25843c4b10a12300">
              <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a12fXOa505a3f19f25843c4b10a12e00">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMStoNOS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a41bXOa505a3f19f25843c4b10a41a00">
              <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a426XOa505a3f19f25843c4b10a42500">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMStoNOS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a31eXOa505a3f19f25843c4b10a31d00">
              <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a329XOa505a3f19f25843c4b10a32800">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMStoNOS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11454dXOa505a3f19f25843c4b11454c00">
              <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b114558XOa505a3f19f25843c4b11455700">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RMStoNOS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a13bXOa505a3f19f25843c4b10a13a00">
              <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a146XOa505a3f19f25843c4b10a14500">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoNOS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a432XOa505a3f19f25843c4b10a43100">
              <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a43dXOa505a3f19f25843c4b10a43c00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoNOS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a335XOa505a3f19f25843c4b10a33400">
              <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a340XOa505a3f19f25843c4b10a33f00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoNOS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b114564XOa505a3f19f25843c4b11456300">
              <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11456fXOa505a3f19f25843c4b11456e00">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoNOS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a152XOa505a3f19f25843c4b10a15100">
              <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a15dXOa505a3f19f25843c4b10a15c00">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoRMS_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a449XOa505a3f19f25843c4b10a44800">
              <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a454XOa505a3f19f25843c4b10a45300">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoRMS_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a34cXOa505a3f19f25843c4b10a34b00">
              <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a357XOa505a3f19f25843c4b10a35600">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoRMS_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11457bXOa505a3f19f25843c4b11457a00">
              <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b114586XOa505a3f19f25843c4b11458500">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NM_RSStoRMS_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a169XOa505a3f19f25843c4b10a16800">
              <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a174XOa505a3f19f25843c4b10a17300">
                  <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NOI_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a460XOa505a3f19f25843c4b10a45f00">
              <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a46bXOa505a3f19f25843c4b10a46a00">
                  <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NOI_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a363XOa505a3f19f25843c4b10a36200">
              <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a36eXOa505a3f19f25843c4b10a36d00">
                  <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NOI_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b114592XOa505a3f19f25843c4b11459100">
              <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11459dXOa505a3f19f25843c4b11459c00">
                  <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NOI_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a197XOa505a3f19f25843c4b10a19600">
              <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a1a2XOa505a3f19f25843c4b10a1a100">
                  <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NWI_BKPCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a48eXOa505a3f19f25843c4b10a48d00">
              <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a499XOa505a3f19f25843c4b10a49800">
                  <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NWI_CHCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a391XOa505a3f19f25843c4b10a39000">
              <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a39cXOa505a3f19f25843c4b10a39b00">
                  <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NWI_PTCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1145a9XOa505a3f19f25843c4b1145a800">
              <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1145b4XOa505a3f19f25843c4b1145b300">
                  <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_NWI_SFCANFD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1028f9XOa505a3f19f25843c4b1028f800">
              <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102904XOa505a3f19f25843c4b10290300">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f95eXOa505a3f19f25843c4b10f95d00">
              <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f969XOa505a3f19f25843c4b10f96800">
                  <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IPD_VehLckCtrlReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111456XOa505a3f19f25843c4b11145500">
              <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111461XOa505a3f19f25843c4b11146000">
                  <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ISGMaxTqLmt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11146dXOa505a3f19f25843c4b11146c00">
              <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111478XOa505a3f19f25843c4b11147700">
                  <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ISGMinTqLmt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111484XOa505a3f19f25843c4b11148300">
              <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11148fXOa505a3f19f25843c4b11148e00">
                  <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ISGTqTgt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e064XOa505a3f19f25843c4b10e06300">
              <SHORT-NAME>IdentityChlg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e06fXOa505a3f19f25843c4b10e06e00">
                  <SHORT-NAME>IdentityChlg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IdentityChlg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1088b4XOa505a3f19f25843c4b1088b300">
              <SHORT-NAME>IgnOffTime</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1088bfXOa505a3f19f25843c4b1088be00">
                  <SHORT-NAME>IgnOffTime</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IgnOffTime</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1088cbXOa505a3f19f25843c4b1088ca00">
              <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1088d6XOa505a3f19f25843c4b1088d500">
                  <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/IgnOffTimeV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc6cXOa505a3f19f25843c4b10fc6b00">
              <SHORT-NAME>JAMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc77XOa505a3f19f25843c4b10fc7600">
                  <SHORT-NAME>JAMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/JAMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f32bXOa505a3f19f25843c4b10f32a00">
              <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f336XOa505a3f19f25843c4b10f33500">
                  <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LADSCurToEndPntDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fbb4XOa505a3f19f25843c4b10fbb300">
              <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fbbfXOa505a3f19f25843c4b10fbbe00">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LADSInfoDispReqToICM_HPP</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10eddeXOa505a3f19f25843c4b10eddd00">
              <SHORT-NAME>LCASelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ede9XOa505a3f19f25843c4b10ede800">
                  <SHORT-NAME>LCASelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LCASelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f639XOa505a3f19f25843c4b10f63800">
              <SHORT-NAME>LCRInHMI</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f644XOa505a3f19f25843c4b10f64300">
                  <SHORT-NAME>LCRInHMI</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LCRInHMI</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f622XOa505a3f19f25843c4b10f62100">
              <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f62dXOa505a3f19f25843c4b10f62c00">
                  <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LCRSwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef09XOa505a3f19f25843c4b10ef0800">
              <SHORT-NAME>LCRSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef14XOa505a3f19f25843c4b10ef1300">
                  <SHORT-NAME>LCRSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LCRSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108910XOa505a3f19f25843c4b10890f00">
              <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10891bXOa505a3f19f25843c4b10891a00">
                  <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LDWAdoWrnngReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108927XOa505a3f19f25843c4b10892600">
              <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108932XOa505a3f19f25843c4b10893100">
                  <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LDWLKAHptWrnngReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10893eXOa505a3f19f25843c4b10893d00">
              <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108949XOa505a3f19f25843c4b10894800">
                  <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LDWLKASwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108955XOa505a3f19f25843c4b10895400">
              <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108960XOa505a3f19f25843c4b10895f00">
                  <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LDWSnstvtLvlReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105624XOa505a3f19f25843c4b10562300">
              <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10562fXOa505a3f19f25843c4b10562e00">
                  <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LDWStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f6c3XOa505a3f19f25843c4b10f6c200">
              <SHORT-NAME>LFCTWrnng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f6ceXOa505a3f19f25843c4b10f6cd00">
                  <SHORT-NAME>LFCTWrnng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LFCTWrnng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c68bXOa505a3f19f25843c4b11c68a00">
              <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c696XOa505a3f19f25843c4b11c69500">
                  <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LFCTWrnng_ADAS</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108983XOa505a3f19f25843c4b10898200">
              <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10898eXOa505a3f19f25843c4b10898d00">
                  <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LHSWPwrSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109e2dXOa505a3f19f25843c4b109e2c00">
              <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109e38XOa505a3f19f25843c4b109e3700">
                  <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/LHZCUAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102fd1XOa505a3f19f25843c4b102fd000">
              <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102fdcXOa505a3f19f25843c4b102fdb00">
                  <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10321eXOa505a3f19f25843c4b10321d00">
              <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10322aXOa505a3f19f25843c4b10322900">
                  <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102f00XOa505a3f19f25843c4b102eff00">
              <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102f0cXOa505a3f19f25843c4b102f0b00">
                  <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102098XOa505a3f19f25843c4b10209700">
              <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1020a3XOa505a3f19f25843c4b1020a200">
                  <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10308bXOa505a3f19f25843c4b10308a00">
              <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103096XOa505a3f19f25843c4b10309500">
                  <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102081XOa505a3f19f25843c4b10208000">
              <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10208cXOa505a3f19f25843c4b10208b00">
                  <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1030feXOa505a3f19f25843c4b1030fd00">
              <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103109XOa505a3f19f25843c4b10310800">
                  <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1051d4XOa505a3f19f25843c4b1051d300">
              <SHORT-NAME>Lane0_C0</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1051dfXOa505a3f19f25843c4b1051de00">
                  <SHORT-NAME>Lane0_C0</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_C0</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1051ebXOa505a3f19f25843c4b1051ea00">
              <SHORT-NAME>Lane0_C1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1051f6XOa505a3f19f25843c4b1051f500">
                  <SHORT-NAME>Lane0_C1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_C1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105202XOa505a3f19f25843c4b10520100">
              <SHORT-NAME>Lane0_C2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10520dXOa505a3f19f25843c4b10520c00">
                  <SHORT-NAME>Lane0_C2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_C2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105219XOa505a3f19f25843c4b10521800">
              <SHORT-NAME>Lane0_C3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105224XOa505a3f19f25843c4b10522300">
                  <SHORT-NAME>Lane0_C3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_C3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105230XOa505a3f19f25843c4b10522f00">
              <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10523bXOa505a3f19f25843c4b10523a00">
                  <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105247XOa505a3f19f25843c4b10524600">
              <SHORT-NAME>Lane0_ID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105252XOa505a3f19f25843c4b10525100">
                  <SHORT-NAME>Lane0_ID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_ID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105275XOa505a3f19f25843c4b10527400">
              <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105280XOa505a3f19f25843c4b10527f00">
                  <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_MarkerColor</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10528cXOa505a3f19f25843c4b10528b00">
              <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105297XOa505a3f19f25843c4b10529600">
                  <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_MarkerType</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1052a3XOa505a3f19f25843c4b1052a200">
              <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1052aeXOa505a3f19f25843c4b1052ad00">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_Part0_SyncFrameIndex</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1052baXOa505a3f19f25843c4b1052b900">
              <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1052c5XOa505a3f19f25843c4b1052c400">
                  <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_ViewRangeEnd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1052d1XOa505a3f19f25843c4b1052d000">
              <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1052dcXOa505a3f19f25843c4b1052db00">
                  <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_ViewRangeStart</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10525eXOa505a3f19f25843c4b10525d00">
              <SHORT-NAME>Lane0_location</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105269XOa505a3f19f25843c4b10526800">
                  <SHORT-NAME>Lane0_location</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane0_location</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1052e8XOa505a3f19f25843c4b1052e700">
              <SHORT-NAME>Lane1_C0</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1052f3XOa505a3f19f25843c4b1052f200">
                  <SHORT-NAME>Lane1_C0</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_C0</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1052ffXOa505a3f19f25843c4b1052fe00">
              <SHORT-NAME>Lane1_C1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10530aXOa505a3f19f25843c4b10530900">
                  <SHORT-NAME>Lane1_C1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_C1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105316XOa505a3f19f25843c4b10531500">
              <SHORT-NAME>Lane1_C2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105321XOa505a3f19f25843c4b10532000">
                  <SHORT-NAME>Lane1_C2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_C2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10532dXOa505a3f19f25843c4b10532c00">
              <SHORT-NAME>Lane1_C3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105338XOa505a3f19f25843c4b10533700">
                  <SHORT-NAME>Lane1_C3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_C3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105344XOa505a3f19f25843c4b10534300">
              <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10534fXOa505a3f19f25843c4b10534e00">
                  <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10535bXOa505a3f19f25843c4b10535a00">
              <SHORT-NAME>Lane1_ID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105366XOa505a3f19f25843c4b10536500">
                  <SHORT-NAME>Lane1_ID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_ID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105389XOa505a3f19f25843c4b10538800">
              <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105394XOa505a3f19f25843c4b10539300">
                  <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_MarkerColor</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1053a0XOa505a3f19f25843c4b10539f00">
              <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1053abXOa505a3f19f25843c4b1053aa00">
                  <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_MarkerType</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1053b7XOa505a3f19f25843c4b1053b600">
              <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1053c2XOa505a3f19f25843c4b1053c100">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_Part0_SyncFrameIndex</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1053ceXOa505a3f19f25843c4b1053cd00">
              <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1053d9XOa505a3f19f25843c4b1053d800">
                  <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_ViewRangeEnd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1053e5XOa505a3f19f25843c4b1053e400">
              <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1053f0XOa505a3f19f25843c4b1053ef00">
                  <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_ViewRangeStart</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105372XOa505a3f19f25843c4b10537100">
              <SHORT-NAME>Lane1_location</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10537dXOa505a3f19f25843c4b10537c00">
                  <SHORT-NAME>Lane1_location</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane1_location</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1053fcXOa505a3f19f25843c4b1053fb00">
              <SHORT-NAME>Lane2_C0</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105407XOa505a3f19f25843c4b10540600">
                  <SHORT-NAME>Lane2_C0</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_C0</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105413XOa505a3f19f25843c4b10541200">
              <SHORT-NAME>Lane2_C1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10541eXOa505a3f19f25843c4b10541d00">
                  <SHORT-NAME>Lane2_C1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_C1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10542aXOa505a3f19f25843c4b10542900">
              <SHORT-NAME>Lane2_C2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105435XOa505a3f19f25843c4b10543400">
                  <SHORT-NAME>Lane2_C2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_C2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105441XOa505a3f19f25843c4b10544000">
              <SHORT-NAME>Lane2_C3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10544cXOa505a3f19f25843c4b10544b00">
                  <SHORT-NAME>Lane2_C3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_C3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105458XOa505a3f19f25843c4b10545700">
              <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105463XOa505a3f19f25843c4b10546200">
                  <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10546fXOa505a3f19f25843c4b10546e00">
              <SHORT-NAME>Lane2_ID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10547aXOa505a3f19f25843c4b10547900">
                  <SHORT-NAME>Lane2_ID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_ID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10549dXOa505a3f19f25843c4b10549c00">
              <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1054a8XOa505a3f19f25843c4b1054a700">
                  <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_MarkerColor</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1054b4XOa505a3f19f25843c4b1054b300">
              <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1054bfXOa505a3f19f25843c4b1054be00">
                  <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_MarkerType</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1054cbXOa505a3f19f25843c4b1054ca00">
              <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1054d6XOa505a3f19f25843c4b1054d500">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_Part0_SyncFrameIndex</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1054e2XOa505a3f19f25843c4b1054e100">
              <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1054edXOa505a3f19f25843c4b1054ec00">
                  <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_ViewRangeEnd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1054f9XOa505a3f19f25843c4b1054f800">
              <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105504XOa505a3f19f25843c4b10550300">
                  <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_ViewRangeStart</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105486XOa505a3f19f25843c4b10548500">
              <SHORT-NAME>Lane2_location</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105491XOa505a3f19f25843c4b10549000">
                  <SHORT-NAME>Lane2_location</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane2_location</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105510XOa505a3f19f25843c4b10550f00">
              <SHORT-NAME>Lane3_C0</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10551bXOa505a3f19f25843c4b10551a00">
                  <SHORT-NAME>Lane3_C0</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_C0</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105527XOa505a3f19f25843c4b10552600">
              <SHORT-NAME>Lane3_C1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105532XOa505a3f19f25843c4b10553100">
                  <SHORT-NAME>Lane3_C1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_C1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10553eXOa505a3f19f25843c4b10553d00">
              <SHORT-NAME>Lane3_C2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105549XOa505a3f19f25843c4b10554800">
                  <SHORT-NAME>Lane3_C2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_C2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105555XOa505a3f19f25843c4b10555400">
              <SHORT-NAME>Lane3_C3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105560XOa505a3f19f25843c4b10555f00">
                  <SHORT-NAME>Lane3_C3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_C3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10556cXOa505a3f19f25843c4b10556b00">
              <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105577XOa505a3f19f25843c4b10557600">
                  <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105583XOa505a3f19f25843c4b10558200">
              <SHORT-NAME>Lane3_ID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10558eXOa505a3f19f25843c4b10558d00">
                  <SHORT-NAME>Lane3_ID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_ID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1055b1XOa505a3f19f25843c4b1055b000">
              <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1055bcXOa505a3f19f25843c4b1055bb00">
                  <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_MarkerColor</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1055c8XOa505a3f19f25843c4b1055c700">
              <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1055d3XOa505a3f19f25843c4b1055d200">
                  <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_MarkerType</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1055dfXOa505a3f19f25843c4b1055de00">
              <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1055eaXOa505a3f19f25843c4b1055e900">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_Part0_SyncFrameIndex</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1055f6XOa505a3f19f25843c4b1055f500">
              <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105601XOa505a3f19f25843c4b10560000">
                  <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_ViewRangeEnd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10560dXOa505a3f19f25843c4b10560c00">
              <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105618XOa505a3f19f25843c4b10561700">
                  <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_ViewRangeStart</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10559aXOa505a3f19f25843c4b10559900">
              <SHORT-NAME>Lane3_location</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1055a5XOa505a3f19f25843c4b1055a400">
                  <SHORT-NAME>Lane3_location</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Lane3_location</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11149bXOa505a3f19f25843c4b11149a00">
              <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1114a6XOa505a3f19f25843c4b1114a500">
                  <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MONSAMTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1114b2XOa505a3f19f25843c4b1114b100">
              <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1114bdXOa505a3f19f25843c4b1114bc00">
                  <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MONTMTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b106441XOa505a3f19f25843c4b10644000">
              <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10644cXOa505a3f19f25843c4b10644b00">
                  <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MainBeamLghtOn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b122603XOa505a3f19f25843c4b12260200">
              <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b12260eXOa505a3f19f25843c4b12260d00">
                  <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MemParkngBtnRcnm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121a98XOa505a3f19f25843c4b121a9700">
              <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121aa3XOa505a3f19f25843c4b121aa200">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MemPkngSlntPtrlEnbSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121a81XOa505a3f19f25843c4b121a8000">
              <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121a8cXOa505a3f19f25843c4b121a8b00">
                  <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MemPkngSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1127d5XOa505a3f19f25843c4b1127d400">
              <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1127e0XOa505a3f19f25843c4b1127df00">
                  <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MnvrngPntDistNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1127ecXOa505a3f19f25843c4b1127eb00">
              <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1127f7XOa505a3f19f25843c4b1127f600">
                  <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/MnvrngPntTypNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f667XOa505a3f19f25843c4b10f66600">
              <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f672XOa505a3f19f25843c4b10f67100">
                  <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOACitySysMsg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f598XOa505a3f19f25843c4b10f59700">
              <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f5a3XOa505a3f19f25843c4b10f5a200">
                  <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOADistDecMsg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f67eXOa505a3f19f25843c4b10f67d00">
              <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f689XOa505a3f19f25843c4b10f68800">
                  <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAETCSetDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef37XOa505a3f19f25843c4b10ef3600">
              <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef42XOa505a3f19f25843c4b10ef4100">
                  <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAETCSetSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f5f4XOa505a3f19f25843c4b10f5f300">
              <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f5ffXOa505a3f19f25843c4b10f5fe00">
                  <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOALaneSetDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10eec4XOa505a3f19f25843c4b10eec300">
              <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eecfXOa505a3f19f25843c4b10eece00">
                  <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOALaneSetSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f60bXOa505a3f19f25843c4b10f60a00">
              <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f616XOa505a3f19f25843c4b10f61500">
                  <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAQukChgSwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10eedbXOa505a3f19f25843c4b10eeda00">
              <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eee6XOa505a3f19f25843c4b10eee500">
                  <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAQukChgSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f5ddXOa505a3f19f25843c4b10f5dc00">
              <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f5e8XOa505a3f19f25843c4b10f5e700">
                  <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAReportSetDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10eeadXOa505a3f19f25843c4b10eeac00">
              <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eeb8XOa505a3f19f25843c4b10eeb700">
                  <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOAReportSetSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f650XOa505a3f19f25843c4b10f64f00">
              <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f65bXOa505a3f19f25843c4b10f65a00">
                  <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOPCitySwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef20XOa505a3f19f25843c4b10ef1f00">
              <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef2bXOa505a3f19f25843c4b10ef2a00">
                  <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOPCitySwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f5afXOa505a3f19f25843c4b10f5ae00">
              <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f5baXOa505a3f19f25843c4b10f5b900">
                  <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOPSwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee96XOa505a3f19f25843c4b10ee9500">
              <SHORT-NAME>NOPSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eea1XOa505a3f19f25843c4b10eea000">
                  <SHORT-NAME>NOPSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOPSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f5c6XOa505a3f19f25843c4b10f5c500">
              <SHORT-NAME>NOPSysMsg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f5d1XOa505a3f19f25843c4b10f5d000">
                  <SHORT-NAME>NOPSysMsg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NOPSysMsg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f131XOa505a3f19f25843c4b10f13000">
              <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f13cXOa505a3f19f25843c4b10f13b00">
                  <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarRoVslAssQuit</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f034XOa505a3f19f25843c4b10f03300">
              <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f03fXOa505a3f19f25843c4b10f03e00">
                  <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarRoVslAssSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f8ebXOa505a3f19f25843c4b10f8ea00">
              <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f8f6XOa505a3f19f25843c4b10f8f500">
                  <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarRoVslAssSwResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f77bXOa505a3f19f25843c4b10f77a00">
              <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f786XOa505a3f19f25843c4b10f78500">
                  <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarrowRoadBackwardSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f792XOa505a3f19f25843c4b10f79100">
              <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f79dXOa505a3f19f25843c4b10f79c00">
                  <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarrowRoadForwardSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f7a9XOa505a3f19f25843c4b10f7a800">
              <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f7b4XOa505a3f19f25843c4b10f7b300">
                  <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarwSpcAstBtnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10efd8XOa505a3f19f25843c4b10efd700">
              <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10efe3XOa505a3f19f25843c4b10efe200">
                  <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarwSpcAstSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f7c0XOa505a3f19f25843c4b10f7bf00">
              <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f7cbXOa505a3f19f25843c4b10f7ca00">
                  <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NarwSpcAstSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119c5cXOa505a3f19f25843c4b119c5b00">
              <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119c67XOa505a3f19f25843c4b119c6600">
                  <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavCndSpdLmtVal</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f18dXOa505a3f19f25843c4b10f18c00">
              <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f198XOa505a3f19f25843c4b10f19700">
                  <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavCrntRoadTyp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119c00XOa505a3f19f25843c4b119bff00">
              <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119c0bXOa505a3f19f25843c4b119c0a00">
                  <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavCtryCode_ISO</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f1a4XOa505a3f19f25843c4b10f1a300">
              <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f1afXOa505a3f19f25843c4b10f1ae00">
                  <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavDistFromFrtEleccEye</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f1bbXOa505a3f19f25843c4b10f1ba00">
              <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f1c6XOa505a3f19f25843c4b10f1c500">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavItvalSpdDetnDistRetDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f1d2XOa505a3f19f25843c4b10f1d100">
              <SHORT-NAME>NavNewIconDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f1ddXOa505a3f19f25843c4b10f1dc00">
                  <SHORT-NAME>NavNewIconDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavNewIconDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119c45XOa505a3f19f25843c4b119c4400">
              <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119c50XOa505a3f19f25843c4b119c4f00">
                  <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavNextRampOffset</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f1e9XOa505a3f19f25843c4b10f1e800">
              <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f1f4XOa505a3f19f25843c4b10f1f300">
                  <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavSpdLmtTyp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119c17XOa505a3f19f25843c4b119c1600">
              <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119c22XOa505a3f19f25843c4b119c2100">
                  <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavSpdLmtVal</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119c2eXOa505a3f19f25843c4b119c2d00">
              <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119c39XOa505a3f19f25843c4b119c3800">
                  <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavSpdLmtValSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f200XOa505a3f19f25843c4b10f1ff00">
              <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f20bXOa505a3f19f25843c4b10f20a00">
                  <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavSpdLmtValUnit</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10eef2XOa505a3f19f25843c4b10eef100">
              <SHORT-NAME>NavSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eefdXOa505a3f19f25843c4b10eefc00">
                  <SHORT-NAME>NavSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NavSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10563bXOa505a3f19f25843c4b10563a00">
              <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105646XOa505a3f19f25843c4b10564500">
                  <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NonDirectDMSSwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1089dfXOa505a3f19f25843c4b1089de00">
              <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1089eaXOa505a3f19f25843c4b1089e900">
                  <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NonDirectDMSSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105652XOa505a3f19f25843c4b10565100">
              <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10565dXOa505a3f19f25843c4b10565c00">
                  <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NonDirectDMSSysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bcb1XOa505a3f19f25843c4b10bcb000">
              <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bcbcXOa505a3f19f25843c4b10bcbb00">
                  <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NorthVelocityRTK</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f930XOa505a3f19f25843c4b10f92f00">
              <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f93bXOa505a3f19f25843c4b10f93a00">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadBwdAssConfrmSwDscmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f062XOa505a3f19f25843c4b10f06100">
              <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f06dXOa505a3f19f25843c4b10f06c00">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadBwdAssConfrmSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f919XOa505a3f19f25843c4b10f91800">
              <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f924XOa505a3f19f25843c4b10f92300">
                  <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadBwdAssMesg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f04bXOa505a3f19f25843c4b10f04a00">
              <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f056XOa505a3f19f25843c4b10f05500">
                  <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadBwdAssSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f902XOa505a3f19f25843c4b10f90100">
              <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f90dXOa505a3f19f25843c4b10f90c00">
                  <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadBwdAssSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f7d7XOa505a3f19f25843c4b10f7d600">
              <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f7e2XOa505a3f19f25843c4b10f7e100">
                  <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdBtnDsp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f7eeXOa505a3f19f25843c4b10f7ed00">
              <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f7f9XOa505a3f19f25843c4b10f7f800">
                  <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdCndNotSt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10efefXOa505a3f19f25843c4b10efee00">
              <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10effaXOa505a3f19f25843c4b10eff900">
                  <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdCtlReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f805XOa505a3f19f25843c4b10f80400">
              <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f810XOa505a3f19f25843c4b10f80f00">
                  <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDsp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f81cXOa505a3f19f25843c4b10f81b00">
              <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f827XOa505a3f19f25843c4b10f82600">
                  <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDst360Req</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f833XOa505a3f19f25843c4b10f83200">
              <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f83eXOa505a3f19f25843c4b10f83d00">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDstBtnDsp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f84aXOa505a3f19f25843c4b10f84900">
              <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f855XOa505a3f19f25843c4b10f85400">
                  <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDstL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f861XOa505a3f19f25843c4b10f86000">
              <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f86cXOa505a3f19f25843c4b10f86b00">
                  <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDstR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f878XOa505a3f19f25843c4b10f87700">
              <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f883XOa505a3f19f25843c4b10f88200">
                  <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdDstTostDsp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f88fXOa505a3f19f25843c4b10f88e00">
              <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f89aXOa505a3f19f25843c4b10f89900">
                  <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdReDst</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f006XOa505a3f19f25843c4b10f00500">
              <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f011XOa505a3f19f25843c4b10f01000">
                  <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f8a6XOa505a3f19f25843c4b10f8a500">
              <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f8b1XOa505a3f19f25843c4b10f8b000">
                  <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdSta</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f8bdXOa505a3f19f25843c4b10f8bc00">
              <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f8c8XOa505a3f19f25843c4b10f8c700">
                  <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadFwdSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f01dXOa505a3f19f25843c4b10f01c00">
              <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f028XOa505a3f19f25843c4b10f02700">
                  <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadsltReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f8d4XOa505a3f19f25843c4b10f8d300">
              <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f8dfXOa505a3f19f25843c4b10f8de00">
                  <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/NrwroadsltSta</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b12319fXOa505a3f19f25843c4b12319e00">
              <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1231abXOa505a3f19f25843c4b1231aa00">
                  <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/OnBdChrgrOptAltPwr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108a0dXOa505a3f19f25843c4b108a0c00">
              <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108a18XOa505a3f19f25843c4b108a1700">
                  <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/OtsdAirTemCrVal</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ed6bXOa505a3f19f25843c4b10ed6a00">
              <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ed76XOa505a3f19f25843c4b10ed7500">
                  <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/OtsdAirTemCrValMsk</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108a24XOa505a3f19f25843c4b108a2300">
              <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108a2fXOa505a3f19f25843c4b108a2e00">
                  <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/OtsdAirTemCrValV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f4f7XOa505a3f19f25843c4b10f4f600">
              <SHORT-NAME>PDCSysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f502XOa505a3f19f25843c4b10f50100">
                  <SHORT-NAME>PDCSysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PDCSysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd80XOa505a3f19f25843c4b10fd7f00">
              <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd8bXOa505a3f19f25843c4b10fd8a00">
                  <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PDSysKeyPsAvlbl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fbf9XOa505a3f19f25843c4b10fbf800">
              <SHORT-NAME>PEBSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc04XOa505a3f19f25843c4b10fc0300">
                  <SHORT-NAME>PEBSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PEBSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f103XOa505a3f19f25843c4b10f10200">
              <SHORT-NAME>PEBSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f10eXOa505a3f19f25843c4b10f10d00">
                  <SHORT-NAME>PEBSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PEBSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fbe2XOa505a3f19f25843c4b10fbe100">
              <SHORT-NAME>PEBSwResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fbedXOa505a3f19f25843c4b10fbec00">
                  <SHORT-NAME>PEBSwResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PEBSwResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fbcbXOa505a3f19f25843c4b10fbca00">
              <SHORT-NAME>PEBWarngReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fbd6XOa505a3f19f25843c4b10fbd500">
                  <SHORT-NAME>PEBWarngReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PEBWarngReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1023daXOa505a3f19f25843c4b1023d900">
              <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1023e5XOa505a3f19f25843c4b1023e400">
                  <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1022adXOa505a3f19f25843c4b1022ac00">
              <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1022b8XOa505a3f19f25843c4b1022b700">
                  <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102b38XOa505a3f19f25843c4b102b3700">
              <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102b43XOa505a3f19f25843c4b102b4200">
                  <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102dd5XOa505a3f19f25843c4b102dd400">
              <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102de0XOa505a3f19f25843c4b102ddf00">
                  <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109dd1XOa505a3f19f25843c4b109dd000">
              <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109ddcXOa505a3f19f25843c4b109ddb00">
                  <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PICU_PTAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c5a5XOa505a3f19f25843c4b11c5a400">
              <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c5b0XOa505a3f19f25843c4b11c5af00">
                  <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngDirAvlSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f0d5XOa505a3f19f25843c4b10f0d400">
              <SHORT-NAME>ParkngDirSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f0e0XOa505a3f19f25843c4b10f0df00">
                  <SHORT-NAME>ParkngDirSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngDirSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c58eXOa505a3f19f25843c4b11c58d00">
              <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c599XOa505a3f19f25843c4b11c59800">
                  <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngDirSwResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c577XOa505a3f19f25843c4b11c57600">
              <SHORT-NAME>ParkngEndDis</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c582XOa505a3f19f25843c4b11c58100">
                  <SHORT-NAME>ParkngEndDis</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngEndDis</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd69XOa505a3f19f25843c4b10fd6800">
              <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd74XOa505a3f19f25843c4b10fd7300">
                  <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngInPrgs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11df9cXOa505a3f19f25843c4b11df9b00">
              <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dfa7XOa505a3f19f25843c4b11dfa600">
                  <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngNCPAvlSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f3b5XOa505a3f19f25843c4b10f3b400">
              <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f3c0XOa505a3f19f25843c4b10f3bf00">
                  <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutBkCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f3ccXOa505a3f19f25843c4b10f3cb00">
              <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f3d7XOa505a3f19f25843c4b10f3d600">
                  <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutBkLCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f3e3XOa505a3f19f25843c4b10f3e200">
              <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f3eeXOa505a3f19f25843c4b10f3ed00">
                  <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutBkRCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f947XOa505a3f19f25843c4b10f94600">
              <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f952XOa505a3f19f25843c4b10f95100">
                  <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutDircnSelResult</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f342XOa505a3f19f25843c4b10f34100">
              <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f34dXOa505a3f19f25843c4b10f34c00">
                  <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutFLCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f359XOa505a3f19f25843c4b10f35800">
              <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f364XOa505a3f19f25843c4b10f36300">
                  <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutFLParllSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f370XOa505a3f19f25843c4b10f36f00">
              <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f37bXOa505a3f19f25843c4b10f37a00">
                  <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutFRCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f387XOa505a3f19f25843c4b10f38600">
              <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f392XOa505a3f19f25843c4b10f39100">
                  <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutFRParllSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f39eXOa505a3f19f25843c4b10f39d00">
              <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f3a9XOa505a3f19f25843c4b10f3a800">
                  <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngOutFrtCrsSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f3faXOa505a3f19f25843c4b10f3f900">
              <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f405XOa505a3f19f25843c4b10f40400">
                  <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngSlotFindSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f0beXOa505a3f19f25843c4b10f0bd00">
              <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f0c9XOa505a3f19f25843c4b10f0c800">
                  <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ParkngSpdSwResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa51XOa505a3f19f25843c4b11fa5000">
              <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fa5cXOa505a3f19f25843c4b11fa5b00">
                  <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysADASFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa68XOa505a3f19f25843c4b11fa6700">
              <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fa73XOa505a3f19f25843c4b11fa7200">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrF1FltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa7fXOa505a3f19f25843c4b11fa7e00">
              <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fa8aXOa505a3f19f25843c4b11fa8900">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrF3FltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11faadXOa505a3f19f25843c4b11faac00">
              <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fab8XOa505a3f19f25843c4b11fab700">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrFLSFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fac4XOa505a3f19f25843c4b11fac300">
              <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11facfXOa505a3f19f25843c4b11face00">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrFRSFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa96XOa505a3f19f25843c4b11fa9500">
              <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11faa1XOa505a3f19f25843c4b11faa000">
                  <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrRFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fadbXOa505a3f19f25843c4b11fada00">
              <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fae6XOa505a3f19f25843c4b11fae500">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrRLSFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11faf2XOa505a3f19f25843c4b11faf100">
              <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fafdXOa505a3f19f25843c4b11fafc00">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysAVCamrRRSFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb65XOa505a3f19f25843c4b11fb6400">
              <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb70XOa505a3f19f25843c4b11fb6f00">
                  <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysFDRFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fbd8XOa505a3f19f25843c4b11fbd700">
              <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fbe3XOa505a3f19f25843c4b11fbe200">
                  <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysFLIDARFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb09XOa505a3f19f25843c4b11fb0800">
              <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb14XOa505a3f19f25843c4b11fb1300">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysHDAVMCamrFFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb37XOa505a3f19f25843c4b11fb3600">
              <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb42XOa505a3f19f25843c4b11fb4100">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysHDAVMCamrLHFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb20XOa505a3f19f25843c4b11fb1f00">
              <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb2bXOa505a3f19f25843c4b11fb2a00">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysHDAVMCamrRFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb4eXOa505a3f19f25843c4b11fb4d00">
              <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb59XOa505a3f19f25843c4b11fb5800">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysHDAVMCamrRHFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb7cXOa505a3f19f25843c4b11fb7b00">
              <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb87XOa505a3f19f25843c4b11fb8600">
                  <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysLFSDAFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fbaaXOa505a3f19f25843c4b11fba900">
              <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fbb5XOa505a3f19f25843c4b11fbb400">
                  <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysLHRDAFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105669XOa505a3f19f25843c4b10566800">
              <SHORT-NAME>PilotSysMsg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105674XOa505a3f19f25843c4b10567300">
                  <SHORT-NAME>PilotSysMsg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysMsg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fb93XOa505a3f19f25843c4b11fb9200">
              <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fb9eXOa505a3f19f25843c4b11fb9d00">
                  <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysRFSDAFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fbc1XOa505a3f19f25843c4b11fbc000">
              <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fbccXOa505a3f19f25843c4b11fbcb00">
                  <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysRHRDAFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fbefXOa505a3f19f25843c4b11fbee00">
              <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fbfaXOa505a3f19f25843c4b11fbf900">
                  <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PilotSysUSSFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b12265fXOa505a3f19f25843c4b12265e00">
              <SHORT-NAME>PosALCFailed</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b12266aXOa505a3f19f25843c4b12266900">
                  <SHORT-NAME>PosALCFailed</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PosALCFailed</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd0dXOa505a3f19f25843c4b10bd0c00">
              <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd18XOa505a3f19f25843c4b10bd1700">
                  <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PositionAttitudeStatus</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c23bXOa505a3f19f25843c4b11c23a00">
              <SHORT-NAME>PrvOutSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c246XOa505a3f19f25843c4b11c24500">
                  <SHORT-NAME>PrvOutSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PrvOutSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1114c9XOa505a3f19f25843c4b1114c800">
              <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1114d4XOa505a3f19f25843c4b1114d300">
                  <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PwrDMd_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1114e0XOa505a3f19f25843c4b1114df00">
              <SHORT-NAME>PwrReq_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1114ebXOa505a3f19f25843c4b1114ea00">
                  <SHORT-NAME>PwrReq_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/PwrReq_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f71fXOa505a3f19f25843c4b10f71e00">
              <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f72aXOa505a3f19f25843c4b10f72900">
                  <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RAAlrWorDis</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef93XOa505a3f19f25843c4b10ef9200">
              <SHORT-NAME>RACtlReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef9eXOa505a3f19f25843c4b10ef9d00">
                  <SHORT-NAME>RACtlReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RACtlReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f6f1XOa505a3f19f25843c4b10f6f000">
              <SHORT-NAME>RADSSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f6fcXOa505a3f19f25843c4b10f6fb00">
                  <SHORT-NAME>RADSSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RADSSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f708XOa505a3f19f25843c4b10f70700">
              <SHORT-NAME>RASysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f713XOa505a3f19f25843c4b10f71200">
                  <SHORT-NAME>RASysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RASysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10edf5XOa505a3f19f25843c4b10edf400">
              <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee00XOa505a3f19f25843c4b10edff00">
                  <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RCTSysSelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee23XOa505a3f19f25843c4b10ee2200">
              <SHORT-NAME>RCWSelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee2eXOa505a3f19f25843c4b10ee2d00">
                  <SHORT-NAME>RCWSelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RCWSelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10edb0XOa505a3f19f25843c4b10edaf00">
              <SHORT-NAME>RDASwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10edbbXOa505a3f19f25843c4b10edba00">
                  <SHORT-NAME>RDASwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RDASwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f6daXOa505a3f19f25843c4b10f6d900">
              <SHORT-NAME>RFCTWrnng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f6e5XOa505a3f19f25843c4b10f6e400">
                  <SHORT-NAME>RFCTWrnng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RFCTWrnng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c6a2XOa505a3f19f25843c4b11c6a100">
              <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c6adXOa505a3f19f25843c4b11c6ac00">
                  <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RFCTWrnng_ADAS</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102f75XOa505a3f19f25843c4b102f7400">
              <SHORT-NAME>RFSDA_20ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102f80XOa505a3f19f25843c4b102f7f00">
                  <SHORT-NAME>RFSDA_20ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102af3XOa505a3f19f25843c4b102af200">
              <SHORT-NAME>RHRDA_50ms_Group04</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102afeXOa505a3f19f25843c4b102afd00">
                  <SHORT-NAME>RHRDA_50ms_Group04</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109e44XOa505a3f19f25843c4b109e4300">
              <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109e4fXOa505a3f19f25843c4b109e4e00">
                  <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RHZCUAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b103206XOa505a3f19f25843c4b10320500">
              <SHORT-NAME>RHZCU_100ms_Group10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103211XOa505a3f19f25843c4b10321000">
                  <SHORT-NAME>RHZCU_100ms_Group10</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1023f1XOa505a3f19f25843c4b1023f000">
              <SHORT-NAME>RHZCU_50ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1023fcXOa505a3f19f25843c4b1023fb00">
                  <SHORT-NAME>RHZCU_50ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1020afXOa505a3f19f25843c4b1020ae00">
              <SHORT-NAME>RHZCU_50ms_Group27</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1020baXOa505a3f19f25843c4b1020b900">
                  <SHORT-NAME>RHZCU_50ms_Group27</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10778bXOa505a3f19f25843c4b10778a00">
              <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107796XOa505a3f19f25843c4b10779500">
                  <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RHZCUeFs1Sts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f46dXOa505a3f19f25843c4b10f46c00">
              <SHORT-NAME>RLObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f478XOa505a3f19f25843c4b10f47700">
                  <SHORT-NAME>RLObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10faceXOa505a3f19f25843c4b10facd00">
              <SHORT-NAME>RLSObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fad9XOa505a3f19f25843c4b10fad800">
                  <SHORT-NAME>RLSObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLSObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f9ffXOa505a3f19f25843c4b10f9fe00">
              <SHORT-NAME>RLSUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa0aXOa505a3f19f25843c4b10fa0900">
                  <SHORT-NAME>RLSUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLSUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f56aXOa505a3f19f25843c4b10f56900">
              <SHORT-NAME>RLSideObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f575XOa505a3f19f25843c4b10f57400">
                  <SHORT-NAME>RLSideObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLSideObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b551XOa505a3f19f25843c4b10b55000">
              <SHORT-NAME>RLTirePrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b55cXOa505a3f19f25843c4b10b55b00">
                  <SHORT-NAME>RLTirePrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLTirePrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b568XOa505a3f19f25843c4b10b56700">
              <SHORT-NAME>RLTirePrsV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b573XOa505a3f19f25843c4b10b57200">
                  <SHORT-NAME>RLTirePrsV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLTirePrsV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f498f2acb354faXNa505a3f19f498f2acb354f400">
              <SHORT-NAME>RLTireSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f498f2acb35507XNa505a3f19f498f2acb3550100">
                  <SHORT-NAME>RLTireSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLTireSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1108bfXOa505a3f19f25843c4b1108be00">
              <SHORT-NAME>RLTireTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1108caXOa505a3f19f25843c4b1108c900">
                  <SHORT-NAME>RLTireTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLTireTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1108d6XOa505a3f19f25843c4b1108d500">
              <SHORT-NAME>RLTireTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1108e1XOa505a3f19f25843c4b1108e000">
                  <SHORT-NAME>RLTireTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLTireTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa16XOa505a3f19f25843c4b10fa1500">
              <SHORT-NAME>RLUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa21XOa505a3f19f25843c4b10fa2000">
                  <SHORT-NAME>RLUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RLUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa2dXOa505a3f19f25843c4b10fa2c00">
              <SHORT-NAME>RMLUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa38XOa505a3f19f25843c4b10fa3700">
                  <SHORT-NAME>RMLUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RMLUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa44XOa505a3f19f25843c4b10fa4300">
              <SHORT-NAME>RMRUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa4fXOa505a3f19f25843c4b10fa4e00">
                  <SHORT-NAME>RMRUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RMRUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ddc9XOa505a3f19f25843c4b10ddc800">
              <SHORT-NAME>RPShockDistL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ddd4XOa505a3f19f25843c4b10ddd300">
                  <SHORT-NAME>RPShockDistL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RPShockDistL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10dde0XOa505a3f19f25843c4b10dddf00">
              <SHORT-NAME>RPShockDistR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ddebXOa505a3f19f25843c4b10ddea00">
                  <SHORT-NAME>RPShockDistR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RPShockDistR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f49bXOa505a3f19f25843c4b10f49a00">
              <SHORT-NAME>RRObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f4a6XOa505a3f19f25843c4b10f4a500">
                  <SHORT-NAME>RRObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fab7XOa505a3f19f25843c4b10fab600">
              <SHORT-NAME>RRSObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fac2XOa505a3f19f25843c4b10fac100">
                  <SHORT-NAME>RRSObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRSObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa5bXOa505a3f19f25843c4b10fa5a00">
              <SHORT-NAME>RRSUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa66XOa505a3f19f25843c4b10fa6500">
                  <SHORT-NAME>RRSUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRSUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f581XOa505a3f19f25843c4b10f58000">
              <SHORT-NAME>RRSideObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f58cXOa505a3f19f25843c4b10f58b00">
                  <SHORT-NAME>RRSideObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRSideObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b57fXOa505a3f19f25843c4b10b57e00">
              <SHORT-NAME>RRTirePrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b58aXOa505a3f19f25843c4b10b58900">
                  <SHORT-NAME>RRTirePrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRTirePrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b596XOa505a3f19f25843c4b10b59500">
              <SHORT-NAME>RRTirePrsV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b5a1XOa505a3f19f25843c4b10b5a000">
                  <SHORT-NAME>RRTirePrsV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRTirePrsV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f498f2acb35914XNa505a3f19f498f2acb3590e00">
              <SHORT-NAME>RRTireSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f498f2acb35921XNa505a3f19f498f2acb3591b00">
                  <SHORT-NAME>RRTireSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRTireSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1108edXOa505a3f19f25843c4b1108ec00">
              <SHORT-NAME>RRTireTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1108f8XOa505a3f19f25843c4b1108f700">
                  <SHORT-NAME>RRTireTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRTireTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110904XOa505a3f19f25843c4b11090300">
              <SHORT-NAME>RRTireTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11090fXOa505a3f19f25843c4b11090e00">
                  <SHORT-NAME>RRTireTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRTireTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa72XOa505a3f19f25843c4b10fa7100">
              <SHORT-NAME>RRUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa7dXOa505a3f19f25843c4b10fa7c00">
                  <SHORT-NAME>RRUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RRUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ec40XOa505a3f19f25843c4b10ec3f00">
              <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ec4bXOa505a3f19f25843c4b10ec4a00">
                  <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RZCUIgnDiagSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ec57XOa505a3f19f25843c4b10ec5600">
              <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ec62XOa505a3f19f25843c4b10ec6100">
                  <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RZCUIgnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102296XOa505a3f19f25843c4b10229500">
              <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1022a1XOa505a3f19f25843c4b1022a000">
                  <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1022dbXOa505a3f19f25843c4b1022da00">
              <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1022e6XOa505a3f19f25843c4b1022e500">
                  <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10234eXOa505a3f19f25843c4b10234d00">
              <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102359XOa505a3f19f25843c4b10235800">
                  <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1029b1XOa505a3f19f25843c4b1029b000">
              <SHORT-NAME>RZCU_10ms_Group22</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1029bcXOa505a3f19f25843c4b1029bb00">
                  <SHORT-NAME>RZCU_10ms_Group22</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10227fXOa505a3f19f25843c4b10227e00">
              <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10228aXOa505a3f19f25843c4b10228900">
                  <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1022f2XOa505a3f19f25843c4b1022f100">
              <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1022fdXOa505a3f19f25843c4b1022fc00">
                  <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1031d3XOa505a3f19f25843c4b1031d200">
              <SHORT-NAME>RZCU_10ms_Group90</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1031deXOa505a3f19f25843c4b1031dd00">
                  <SHORT-NAME>RZCU_10ms_Group90</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102309XOa505a3f19f25843c4b10230800">
              <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102314XOa505a3f19f25843c4b10231300">
                  <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102fbaXOa505a3f19f25843c4b102fb900">
              <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102fc5XOa505a3f19f25843c4b102fc400">
                  <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1136a8XOa505a3f19f25843c4b1136a700">
              <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1136b3XOa505a3f19f25843c4b1136b200">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RZCU_BKBCANFDAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102983XOa505a3f19f25843c4b10298200">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10298eXOa505a3f19f25843c4b10298d00">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e0c0XOa505a3f19f25843c4b10e0bf00">
              <SHORT-NAME>ResetCnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e0cbXOa505a3f19f25843c4b10e0ca00">
                  <SHORT-NAME>ResetCnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ResetCnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c252XOa505a3f19f25843c4b11c25100">
              <SHORT-NAME>RoadHeightL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c25dXOa505a3f19f25843c4b11c25c00">
                  <SHORT-NAME>RoadHeightL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadHeightL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c269XOa505a3f19f25843c4b11c26800">
              <SHORT-NAME>RoadHeightR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c274XOa505a3f19f25843c4b11c27300">
                  <SHORT-NAME>RoadHeightR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadHeightR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10de98XOa505a3f19f25843c4b10de9700">
              <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10dea3XOa505a3f19f25843c4b10dea200">
                  <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c280XOa505a3f19f25843c4b11c27f00">
              <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c28bXOa505a3f19f25843c4b11c28a00">
                  <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceL1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c297XOa505a3f19f25843c4b11c29600">
              <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c2a2XOa505a3f19f25843c4b11c2a100">
                  <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceL2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c2aeXOa505a3f19f25843c4b11c2ad00">
              <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c2b9XOa505a3f19f25843c4b11c2b800">
                  <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceL3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10deafXOa505a3f19f25843c4b10deae00">
              <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10debaXOa505a3f19f25843c4b10deb900">
                  <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c2c5XOa505a3f19f25843c4b11c2c400">
              <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c2d0XOa505a3f19f25843c4b11c2cf00">
                  <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceR1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c2dcXOa505a3f19f25843c4b11c2db00">
              <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c2e7XOa505a3f19f25843c4b11c2e600">
                  <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceR2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c2f3XOa505a3f19f25843c4b11c2f200">
              <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c2feXOa505a3f19f25843c4b11c2fd00">
                  <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockConfidenceR3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10dec6XOa505a3f19f25843c4b10dec500">
              <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ded1XOa505a3f19f25843c4b10ded000">
                  <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b3eeXOa505a3f19f25843c4b11b3ed00">
              <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b3f9XOa505a3f19f25843c4b11b3f800">
                  <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedL1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c30aXOa505a3f19f25843c4b11c30900">
              <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c315XOa505a3f19f25843c4b11c31400">
                  <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedL2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c321XOa505a3f19f25843c4b11c32000">
              <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c32cXOa505a3f19f25843c4b11c32b00">
                  <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedL3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10deddXOa505a3f19f25843c4b10dedc00">
              <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10dee8XOa505a3f19f25843c4b10dee700">
                  <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b405XOa505a3f19f25843c4b11b40400">
              <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b410XOa505a3f19f25843c4b11b40f00">
                  <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedR1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c338XOa505a3f19f25843c4b11c33700">
              <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c343XOa505a3f19f25843c4b11c34200">
                  <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedR2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c34fXOa505a3f19f25843c4b11c34e00">
              <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c35aXOa505a3f19f25843c4b11c35900">
                  <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDetectedR3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c37dXOa505a3f19f25843c4b11c37c00">
              <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c388XOa505a3f19f25843c4b11c38700">
                  <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistL1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c394XOa505a3f19f25843c4b11c39300">
              <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c39fXOa505a3f19f25843c4b11c39e00">
                  <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistL2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c3abXOa505a3f19f25843c4b11c3aa00">
              <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c3b6XOa505a3f19f25843c4b11c3b500">
                  <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistL3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c3c2XOa505a3f19f25843c4b11c3c100">
              <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c3cdXOa505a3f19f25843c4b11c3cc00">
                  <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistR1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c3d9XOa505a3f19f25843c4b11c3d800">
              <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c3e4XOa505a3f19f25843c4b11c3e300">
                  <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistR2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c3f0XOa505a3f19f25843c4b11c3ef00">
              <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c3fbXOa505a3f19f25843c4b11c3fa00">
                  <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockDistR3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10def4XOa505a3f19f25843c4b10def300">
              <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10deffXOa505a3f19f25843c4b10defe00">
                  <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c407XOa505a3f19f25843c4b11c40600">
              <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c412XOa505a3f19f25843c4b11c41100">
                  <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightL1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c41eXOa505a3f19f25843c4b11c41d00">
              <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c429XOa505a3f19f25843c4b11c42800">
                  <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightL2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c435XOa505a3f19f25843c4b11c43400">
              <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c440XOa505a3f19f25843c4b11c43f00">
                  <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightL3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10df0bXOa505a3f19f25843c4b10df0a00">
              <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10df16XOa505a3f19f25843c4b10df1500">
                  <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c44cXOa505a3f19f25843c4b11c44b00">
              <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c457XOa505a3f19f25843c4b11c45600">
                  <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightR1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c463XOa505a3f19f25843c4b11c46200">
              <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c46eXOa505a3f19f25843c4b11c46d00">
                  <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightR2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c47aXOa505a3f19f25843c4b11c47900">
              <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c485XOa505a3f19f25843c4b11c48400">
                  <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockHeightR3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10df39XOa505a3f19f25843c4b10df3800">
              <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10df44XOa505a3f19f25843c4b10df4300">
                  <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockLevelL</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10df50XOa505a3f19f25843c4b10df4f00">
              <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10df5bXOa505a3f19f25843c4b10df5a00">
                  <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RoadProfileShockLevelR</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1114f7XOa505a3f19f25843c4b1114f600">
              <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111502XOa505a3f19f25843c4b11150100">
                  <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Rolloff2Min_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11150eXOa505a3f19f25843c4b11150d00">
              <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111519XOa505a3f19f25843c4b11151800">
                  <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RolloffHld_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f4b2XOa505a3f19f25843c4b10f4b100">
              <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f4bdXOa505a3f19f25843c4b10f4bc00">
                  <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RrMidLObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f484XOa505a3f19f25843c4b10f48300">
              <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f48fXOa505a3f19f25843c4b10f48e00">
                  <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RrMidRObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f4e0XOa505a3f19f25843c4b10f4df00">
              <SHORT-NAME>RrObsDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f4ebXOa505a3f19f25843c4b10f4ea00">
                  <SHORT-NAME>RrObsDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RrObsDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f525XOa505a3f19f25843c4b10f52400">
              <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f530XOa505a3f19f25843c4b10f52f00">
                  <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RrPDCAudWrnng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b89eXOa505a3f19f25843c4b11b89d00">
              <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b8a9XOa505a3f19f25843c4b11b8a800">
                  <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RrTireStdPrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108adcXOa505a3f19f25843c4b108adb00">
              <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108ae7XOa505a3f19f25843c4b108ae600">
                  <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/RstrFctryDeftsReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109e5bXOa505a3f19f25843c4b109e5a00">
              <SHORT-NAME>SDMAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109e66XOa505a3f19f25843c4b109e6500">
                  <SHORT-NAME>SDMAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SDMAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1020c6XOa505a3f19f25843c4b1020c500">
              <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1020d1XOa505a3f19f25843c4b1020d000">
                  <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1020ddXOa505a3f19f25843c4b1020dc00">
              <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1020e8XOa505a3f19f25843c4b1020e700">
                  <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1021deXOa505a3f19f25843c4b1021dd00">
              <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1021e9XOa505a3f19f25843c4b1021e800">
                  <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dc60XOa505a3f19f25843c4b11dc5f00">
              <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dc6bXOa505a3f19f25843c4b11dc6a00">
                  <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFAudWrnng_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105680XOa505a3f19f25843c4b10567f00">
              <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10568bXOa505a3f19f25843c4b10568a00">
                  <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFSts_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b123339XOa505a3f19f25843c4b12333800">
              <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b123344XOa505a3f19f25843c4b12334300">
                  <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFSysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1109bcXOa505a3f19f25843c4b1109bb00">
              <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1109c7XOa505a3f19f25843c4b1109c600">
                  <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFUpdtIndReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dc77XOa505a3f19f25843c4b11dc7600">
              <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dc82XOa505a3f19f25843c4b11dc8100">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFUpdtIndResp_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11dc8eXOa505a3f19f25843c4b11dc8d00">
              <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11dc99XOa505a3f19f25843c4b11dc9800">
                  <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFUpdtInd_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119be9XOa505a3f19f25843c4b119be800">
              <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119bf4XOa505a3f19f25843c4b119bf300">
                  <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFWrnngMdReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c618XOa505a3f19f25843c4b11c61700">
              <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c623XOa505a3f19f25843c4b11c62200">
                  <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SLIFWrnngMdResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111525XOa505a3f19f25843c4b11152400">
              <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111530XOa505a3f19f25843c4b11152f00">
                  <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SOCLowPwrDwn_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11153cXOa505a3f19f25843c4b11153b00">
              <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111547XOa505a3f19f25843c4b11154600">
                  <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SOCLvl_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111553XOa505a3f19f25843c4b11155200">
              <SHORT-NAME>SOCMd_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11155eXOa505a3f19f25843c4b11155d00">
                  <SHORT-NAME>SOCMd_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SOCMd_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd24XOa505a3f19f25843c4b10bd2300">
              <SHORT-NAME>SatAz1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd2fXOa505a3f19f25843c4b10bd2e00">
                  <SHORT-NAME>SatAz1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd3bXOa505a3f19f25843c4b10bd3a00">
              <SHORT-NAME>SatAz10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd46XOa505a3f19f25843c4b10bd4500">
                  <SHORT-NAME>SatAz10</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd52XOa505a3f19f25843c4b10bd5100">
              <SHORT-NAME>SatAz11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd5dXOa505a3f19f25843c4b10bd5c00">
                  <SHORT-NAME>SatAz11</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd69XOa505a3f19f25843c4b10bd6800">
              <SHORT-NAME>SatAz12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd74XOa505a3f19f25843c4b10bd7300">
                  <SHORT-NAME>SatAz12</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd80XOa505a3f19f25843c4b10bd7f00">
              <SHORT-NAME>SatAz13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bd8bXOa505a3f19f25843c4b10bd8a00">
                  <SHORT-NAME>SatAz13</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bd97XOa505a3f19f25843c4b10bd9600">
              <SHORT-NAME>SatAz14</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bda2XOa505a3f19f25843c4b10bda100">
                  <SHORT-NAME>SatAz14</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz14</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bdaeXOa505a3f19f25843c4b10bdad00">
              <SHORT-NAME>SatAz15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bdb9XOa505a3f19f25843c4b10bdb800">
                  <SHORT-NAME>SatAz15</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bdc5XOa505a3f19f25843c4b10bdc400">
              <SHORT-NAME>SatAz16</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bdd0XOa505a3f19f25843c4b10bdcf00">
                  <SHORT-NAME>SatAz16</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz16</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bddcXOa505a3f19f25843c4b10bddb00">
              <SHORT-NAME>SatAz17</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bde7XOa505a3f19f25843c4b10bde600">
                  <SHORT-NAME>SatAz17</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz17</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bdf3XOa505a3f19f25843c4b10bdf200">
              <SHORT-NAME>SatAz18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bdfeXOa505a3f19f25843c4b10bdfd00">
                  <SHORT-NAME>SatAz18</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be0aXOa505a3f19f25843c4b10be0900">
              <SHORT-NAME>SatAz19</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be15XOa505a3f19f25843c4b10be1400">
                  <SHORT-NAME>SatAz19</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz19</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be21XOa505a3f19f25843c4b10be2000">
              <SHORT-NAME>SatAz2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be2cXOa505a3f19f25843c4b10be2b00">
                  <SHORT-NAME>SatAz2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be38XOa505a3f19f25843c4b10be3700">
              <SHORT-NAME>SatAz20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be43XOa505a3f19f25843c4b10be4200">
                  <SHORT-NAME>SatAz20</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be4fXOa505a3f19f25843c4b10be4e00">
              <SHORT-NAME>SatAz3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be5aXOa505a3f19f25843c4b10be5900">
                  <SHORT-NAME>SatAz3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be66XOa505a3f19f25843c4b10be6500">
              <SHORT-NAME>SatAz4</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be71XOa505a3f19f25843c4b10be7000">
                  <SHORT-NAME>SatAz4</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz4</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be7dXOa505a3f19f25843c4b10be7c00">
              <SHORT-NAME>SatAz5</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be88XOa505a3f19f25843c4b10be8700">
                  <SHORT-NAME>SatAz5</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz5</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10be94XOa505a3f19f25843c4b10be9300">
              <SHORT-NAME>SatAz6</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10be9fXOa505a3f19f25843c4b10be9e00">
                  <SHORT-NAME>SatAz6</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz6</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10beabXOa505a3f19f25843c4b10beaa00">
              <SHORT-NAME>SatAz7</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10beb6XOa505a3f19f25843c4b10beb500">
                  <SHORT-NAME>SatAz7</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz7</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bec2XOa505a3f19f25843c4b10bec100">
              <SHORT-NAME>SatAz8</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10becdXOa505a3f19f25843c4b10becc00">
                  <SHORT-NAME>SatAz8</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz8</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bed9XOa505a3f19f25843c4b10bed800">
              <SHORT-NAME>SatAz9</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bee4XOa505a3f19f25843c4b10bee300">
                  <SHORT-NAME>SatAz9</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatAz9</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bef0XOa505a3f19f25843c4b10beef00">
              <SHORT-NAME>SatCNO1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10befbXOa505a3f19f25843c4b10befa00">
                  <SHORT-NAME>SatCNO1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf07XOa505a3f19f25843c4b10bf0600">
              <SHORT-NAME>SatCNO10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf12XOa505a3f19f25843c4b10bf1100">
                  <SHORT-NAME>SatCNO10</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf1eXOa505a3f19f25843c4b10bf1d00">
              <SHORT-NAME>SatCNO11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf29XOa505a3f19f25843c4b10bf2800">
                  <SHORT-NAME>SatCNO11</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf35XOa505a3f19f25843c4b10bf3400">
              <SHORT-NAME>SatCNO12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf40XOa505a3f19f25843c4b10bf3f00">
                  <SHORT-NAME>SatCNO12</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf4cXOa505a3f19f25843c4b10bf4b00">
              <SHORT-NAME>SatCNO13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf57XOa505a3f19f25843c4b10bf5600">
                  <SHORT-NAME>SatCNO13</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf63XOa505a3f19f25843c4b10bf6200">
              <SHORT-NAME>SatCNO14</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf6eXOa505a3f19f25843c4b10bf6d00">
                  <SHORT-NAME>SatCNO14</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO14</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf7aXOa505a3f19f25843c4b10bf7900">
              <SHORT-NAME>SatCNO15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf85XOa505a3f19f25843c4b10bf8400">
                  <SHORT-NAME>SatCNO15</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bf91XOa505a3f19f25843c4b10bf9000">
              <SHORT-NAME>SatCNO16</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bf9cXOa505a3f19f25843c4b10bf9b00">
                  <SHORT-NAME>SatCNO16</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO16</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bfa8XOa505a3f19f25843c4b10bfa700">
              <SHORT-NAME>SatCNO17</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bfb3XOa505a3f19f25843c4b10bfb200">
                  <SHORT-NAME>SatCNO17</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO17</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bfbfXOa505a3f19f25843c4b10bfbe00">
              <SHORT-NAME>SatCNO18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bfcaXOa505a3f19f25843c4b10bfc900">
                  <SHORT-NAME>SatCNO18</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bfd6XOa505a3f19f25843c4b10bfd500">
              <SHORT-NAME>SatCNO19</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bfe1XOa505a3f19f25843c4b10bfe000">
                  <SHORT-NAME>SatCNO19</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO19</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bfedXOa505a3f19f25843c4b10bfec00">
              <SHORT-NAME>SatCNO2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bff8XOa505a3f19f25843c4b10bff700">
                  <SHORT-NAME>SatCNO2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c004XOa505a3f19f25843c4b10c00300">
              <SHORT-NAME>SatCNO20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c00fXOa505a3f19f25843c4b10c00e00">
                  <SHORT-NAME>SatCNO20</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c01bXOa505a3f19f25843c4b10c01a00">
              <SHORT-NAME>SatCNO3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c026XOa505a3f19f25843c4b10c02500">
                  <SHORT-NAME>SatCNO3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c032XOa505a3f19f25843c4b10c03100">
              <SHORT-NAME>SatCNO4</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c03dXOa505a3f19f25843c4b10c03c00">
                  <SHORT-NAME>SatCNO4</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO4</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c049XOa505a3f19f25843c4b10c04800">
              <SHORT-NAME>SatCNO5</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c054XOa505a3f19f25843c4b10c05300">
                  <SHORT-NAME>SatCNO5</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO5</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c060XOa505a3f19f25843c4b10c05f00">
              <SHORT-NAME>SatCNO6</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c06bXOa505a3f19f25843c4b10c06a00">
                  <SHORT-NAME>SatCNO6</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO6</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c077XOa505a3f19f25843c4b10c07600">
              <SHORT-NAME>SatCNO7</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c082XOa505a3f19f25843c4b10c08100">
                  <SHORT-NAME>SatCNO7</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO7</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c08eXOa505a3f19f25843c4b10c08d00">
              <SHORT-NAME>SatCNO8</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c099XOa505a3f19f25843c4b10c09800">
                  <SHORT-NAME>SatCNO8</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO8</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c0a5XOa505a3f19f25843c4b10c0a400">
              <SHORT-NAME>SatCNO9</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c0b0XOa505a3f19f25843c4b10c0af00">
                  <SHORT-NAME>SatCNO9</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatCNO9</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c0bcXOa505a3f19f25843c4b10c0bb00">
              <SHORT-NAME>SatElv1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c0c7XOa505a3f19f25843c4b10c0c600">
                  <SHORT-NAME>SatElv1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c0d3XOa505a3f19f25843c4b10c0d200">
              <SHORT-NAME>SatElv10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c0deXOa505a3f19f25843c4b10c0dd00">
                  <SHORT-NAME>SatElv10</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c0eaXOa505a3f19f25843c4b10c0e900">
              <SHORT-NAME>SatElv11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c0f5XOa505a3f19f25843c4b10c0f400">
                  <SHORT-NAME>SatElv11</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c101XOa505a3f19f25843c4b10c10000">
              <SHORT-NAME>SatElv12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c10cXOa505a3f19f25843c4b10c10b00">
                  <SHORT-NAME>SatElv12</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c118XOa505a3f19f25843c4b10c11700">
              <SHORT-NAME>SatElv13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c123XOa505a3f19f25843c4b10c12200">
                  <SHORT-NAME>SatElv13</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c12fXOa505a3f19f25843c4b10c12e00">
              <SHORT-NAME>SatElv14</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c13aXOa505a3f19f25843c4b10c13900">
                  <SHORT-NAME>SatElv14</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv14</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c146XOa505a3f19f25843c4b10c14500">
              <SHORT-NAME>SatElv15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c151XOa505a3f19f25843c4b10c15000">
                  <SHORT-NAME>SatElv15</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c15dXOa505a3f19f25843c4b10c15c00">
              <SHORT-NAME>SatElv16</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c168XOa505a3f19f25843c4b10c16700">
                  <SHORT-NAME>SatElv16</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv16</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c174XOa505a3f19f25843c4b10c17300">
              <SHORT-NAME>SatElv17</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c17fXOa505a3f19f25843c4b10c17e00">
                  <SHORT-NAME>SatElv17</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv17</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c18bXOa505a3f19f25843c4b10c18a00">
              <SHORT-NAME>SatElv18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c196XOa505a3f19f25843c4b10c19500">
                  <SHORT-NAME>SatElv18</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c1a2XOa505a3f19f25843c4b10c1a100">
              <SHORT-NAME>SatElv19</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c1adXOa505a3f19f25843c4b10c1ac00">
                  <SHORT-NAME>SatElv19</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv19</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c1b9XOa505a3f19f25843c4b10c1b800">
              <SHORT-NAME>SatElv2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c1c4XOa505a3f19f25843c4b10c1c300">
                  <SHORT-NAME>SatElv2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c1d0XOa505a3f19f25843c4b10c1cf00">
              <SHORT-NAME>SatElv20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c1dbXOa505a3f19f25843c4b10c1da00">
                  <SHORT-NAME>SatElv20</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c1e7XOa505a3f19f25843c4b10c1e600">
              <SHORT-NAME>SatElv3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c1f2XOa505a3f19f25843c4b10c1f100">
                  <SHORT-NAME>SatElv3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c1feXOa505a3f19f25843c4b10c1fd00">
              <SHORT-NAME>SatElv4</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c209XOa505a3f19f25843c4b10c20800">
                  <SHORT-NAME>SatElv4</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv4</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c215XOa505a3f19f25843c4b10c21400">
              <SHORT-NAME>SatElv5</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c220XOa505a3f19f25843c4b10c21f00">
                  <SHORT-NAME>SatElv5</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv5</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c22cXOa505a3f19f25843c4b10c22b00">
              <SHORT-NAME>SatElv6</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c237XOa505a3f19f25843c4b10c23600">
                  <SHORT-NAME>SatElv6</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv6</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c243XOa505a3f19f25843c4b10c24200">
              <SHORT-NAME>SatElv7</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c24eXOa505a3f19f25843c4b10c24d00">
                  <SHORT-NAME>SatElv7</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv7</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c25aXOa505a3f19f25843c4b10c25900">
              <SHORT-NAME>SatElv8</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c265XOa505a3f19f25843c4b10c26400">
                  <SHORT-NAME>SatElv8</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv8</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c271XOa505a3f19f25843c4b10c27000">
              <SHORT-NAME>SatElv9</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c27cXOa505a3f19f25843c4b10c27b00">
                  <SHORT-NAME>SatElv9</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatElv9</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c288XOa505a3f19f25843c4b10c28700">
              <SHORT-NAME>SatID1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c293XOa505a3f19f25843c4b10c29200">
                  <SHORT-NAME>SatID1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c29fXOa505a3f19f25843c4b10c29e00">
              <SHORT-NAME>SatID10</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c2aaXOa505a3f19f25843c4b10c2a900">
                  <SHORT-NAME>SatID10</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID10</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c2b6XOa505a3f19f25843c4b10c2b500">
              <SHORT-NAME>SatID11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c2c1XOa505a3f19f25843c4b10c2c000">
                  <SHORT-NAME>SatID11</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c2cdXOa505a3f19f25843c4b10c2cc00">
              <SHORT-NAME>SatID12</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c2d8XOa505a3f19f25843c4b10c2d700">
                  <SHORT-NAME>SatID12</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID12</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c2e4XOa505a3f19f25843c4b10c2e300">
              <SHORT-NAME>SatID13</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c2efXOa505a3f19f25843c4b10c2ee00">
                  <SHORT-NAME>SatID13</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID13</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c2fbXOa505a3f19f25843c4b10c2fa00">
              <SHORT-NAME>SatID14</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c306XOa505a3f19f25843c4b10c30500">
                  <SHORT-NAME>SatID14</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID14</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c312XOa505a3f19f25843c4b10c31100">
              <SHORT-NAME>SatID15</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c31dXOa505a3f19f25843c4b10c31c00">
                  <SHORT-NAME>SatID15</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID15</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c329XOa505a3f19f25843c4b10c32800">
              <SHORT-NAME>SatID16</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c334XOa505a3f19f25843c4b10c33300">
                  <SHORT-NAME>SatID16</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID16</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c340XOa505a3f19f25843c4b10c33f00">
              <SHORT-NAME>SatID17</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c34bXOa505a3f19f25843c4b10c34a00">
                  <SHORT-NAME>SatID17</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID17</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c357XOa505a3f19f25843c4b10c35600">
              <SHORT-NAME>SatID18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c362XOa505a3f19f25843c4b10c36100">
                  <SHORT-NAME>SatID18</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c36eXOa505a3f19f25843c4b10c36d00">
              <SHORT-NAME>SatID19</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c379XOa505a3f19f25843c4b10c37800">
                  <SHORT-NAME>SatID19</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID19</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c385XOa505a3f19f25843c4b10c38400">
              <SHORT-NAME>SatID2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c390XOa505a3f19f25843c4b10c38f00">
                  <SHORT-NAME>SatID2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c39cXOa505a3f19f25843c4b10c39b00">
              <SHORT-NAME>SatID20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c3a7XOa505a3f19f25843c4b10c3a600">
                  <SHORT-NAME>SatID20</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c3b3XOa505a3f19f25843c4b10c3b200">
              <SHORT-NAME>SatID3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c3beXOa505a3f19f25843c4b10c3bd00">
                  <SHORT-NAME>SatID3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c3caXOa505a3f19f25843c4b10c3c900">
              <SHORT-NAME>SatID4</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c3d5XOa505a3f19f25843c4b10c3d400">
                  <SHORT-NAME>SatID4</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID4</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c3e1XOa505a3f19f25843c4b10c3e000">
              <SHORT-NAME>SatID5</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c3ecXOa505a3f19f25843c4b10c3eb00">
                  <SHORT-NAME>SatID5</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID5</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c3f8XOa505a3f19f25843c4b10c3f700">
              <SHORT-NAME>SatID6</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c403XOa505a3f19f25843c4b10c40200">
                  <SHORT-NAME>SatID6</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID6</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c40fXOa505a3f19f25843c4b10c40e00">
              <SHORT-NAME>SatID7</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c41aXOa505a3f19f25843c4b10c41900">
                  <SHORT-NAME>SatID7</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID7</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c426XOa505a3f19f25843c4b10c42500">
              <SHORT-NAME>SatID8</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c431XOa505a3f19f25843c4b10c43000">
                  <SHORT-NAME>SatID8</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID8</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c43dXOa505a3f19f25843c4b10c43c00">
              <SHORT-NAME>SatID9</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c448XOa505a3f19f25843c4b10c44700">
                  <SHORT-NAME>SatID9</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatID9</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c454XOa505a3f19f25843c4b10c45300">
              <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c45fXOa505a3f19f25843c4b10c45e00">
                  <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatNoInAttitudeRTK</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c46bXOa505a3f19f25843c4b10c46a00">
              <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c476XOa505a3f19f25843c4b10c47500">
                  <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatNoInPositionRTK</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c482XOa505a3f19f25843c4b10c48100">
              <SHORT-NAME>SatNum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c48dXOa505a3f19f25843c4b10c48c00">
                  <SHORT-NAME>SatNum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SatNum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107e8dXOa505a3f19f25843c4b107e8c00">
              <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107e98XOa505a3f19f25843c4b107e9700">
                  <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SeatOccptnNum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11156aXOa505a3f19f25843c4b11156900">
              <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111575XOa505a3f19f25843c4b11157400">
                  <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ShftSeqStat_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b106583XOa505a3f19f25843c4b10658200">
              <SHORT-NAME>SideLghtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10658eXOa505a3f19f25843c4b10658d00">
                  <SHORT-NAME>SideLghtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SideLghtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1230e1XOa505a3f19f25843c4b1230e000">
              <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1230ecXOa505a3f19f25843c4b1230eb00">
                  <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdAstCndStsCamr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105697XOa505a3f19f25843c4b10569600">
              <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1056a2XOa505a3f19f25843c4b1056a100">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdAstSysTrgtSpd_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1056aeXOa505a3f19f25843c4b1056ad00">
              <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1056b9XOa505a3f19f25843c4b1056b800">
                  <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLimitManualSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1056c5XOa505a3f19f25843c4b1056c400">
              <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1056d0XOa505a3f19f25843c4b1056cf00">
                  <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtMdMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1056dcXOa505a3f19f25843c4b1056db00">
              <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1056e7XOa505a3f19f25843c4b1056e600">
                  <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtMdResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1107a7XOa505a3f19f25843c4b1107a600">
              <SHORT-NAME>SpdLmtNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1107b2XOa505a3f19f25843c4b1107b100">
                  <SHORT-NAME>SpdLmtNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108b4fXOa505a3f19f25843c4b108b4e00">
              <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108b5aXOa505a3f19f25843c4b108b5900">
                  <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetNumReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1056f3XOa505a3f19f25843c4b1056f200">
              <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1056feXOa505a3f19f25843c4b1056fd00">
                  <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetNumResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108b66XOa505a3f19f25843c4b108b6500">
              <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108b71XOa505a3f19f25843c4b108b7000">
                  <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetPercReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10570aXOa505a3f19f25843c4b10570900">
              <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105715XOa505a3f19f25843c4b10571400">
                  <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetPercResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108b7dXOa505a3f19f25843c4b108b7c00">
              <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108b88XOa505a3f19f25843c4b108b8700">
                  <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105721XOa505a3f19f25843c4b10572000">
              <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10572cXOa505a3f19f25843c4b10572b00">
                  <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtOfstSetResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11091bXOa505a3f19f25843c4b11091a00">
              <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110926XOa505a3f19f25843c4b11092500">
                  <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpdLmtPathRngNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f0a7XOa505a3f19f25843c4b10f0a600">
              <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f0b2XOa505a3f19f25843c4b10f0b100">
                  <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpedRegulaModSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb2aXOa505a3f19f25843c4b10fb2900">
              <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb35XOa505a3f19f25843c4b10fb3400">
                  <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SpedRegulaModSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1115afXOa505a3f19f25843c4b1115ae00">
              <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1115baXOa505a3f19f25843c4b1115b900">
                  <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/StrtTypAvail_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c499XOa505a3f19f25843c4b10c49800">
              <SHORT-NAME>SvGroup</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c4a4XOa505a3f19f25843c4b10c4a300">
                  <SHORT-NAME>SvGroup</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/SvGroup</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1115c6XOa505a3f19f25843c4b1115c500">
              <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1115d1XOa505a3f19f25843c4b1115d000">
                  <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TASSAMTqSplt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1115ddXOa505a3f19f25843c4b1115dc00">
              <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1115e8XOa505a3f19f25843c4b1115e700">
                  <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TASTMTqSplt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102f47XOa505a3f19f25843c4b102f4600">
              <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102f52XOa505a3f19f25843c4b102f5100">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102e5fXOa505a3f19f25843c4b102e5e00">
              <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102e6aXOa505a3f19f25843c4b102e6900">
                  <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f5902a13b367abXNa505a3f19f5902a13b367a500">
              <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f5902a13b367b8XNa505a3f19f5902a13b367b200">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f5902a13b3658eXNa505a3f19f5902a13b3658800">
              <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f5902a13b3659bXNa505a3f19f5902a13b3659500">
                  <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1115f4XOa505a3f19f25843c4b1115f300">
              <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1115ffXOa505a3f19f25843c4b1115fe00">
                  <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TCUIntvSAMTq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11160bXOa505a3f19f25843c4b11160a00">
              <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111616XOa505a3f19f25843c4b11161500">
                  <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TCUIntvTMTq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111622XOa505a3f19f25843c4b11162100">
              <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11162dXOa505a3f19f25843c4b11162c00">
                  <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TCUOpSt_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b72cXOa505a3f19f25843c4b11b72b00">
              <SHORT-NAME>TDMAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b738XOa505a3f19f25843c4b11b73700">
                  <SHORT-NAME>TDMAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TDMAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b103146XOa505a3f19f25843c4b10314500">
              <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103152XOa505a3f19f25843c4b10315100">
                  <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105738XOa505a3f19f25843c4b10573700">
              <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105743XOa505a3f19f25843c4b10574200">
                  <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TJAICAMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10574fXOa505a3f19f25843c4b10574e00">
              <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10575aXOa505a3f19f25843c4b10575900">
                  <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TLRMdSwDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108bf0XOa505a3f19f25843c4b108bef00">
              <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108bfbXOa505a3f19f25843c4b108bfa00">
                  <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TLRMdSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105766XOa505a3f19f25843c4b10576500">
              <SHORT-NAME>TLRMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105771XOa505a3f19f25843c4b10577000">
                  <SHORT-NAME>TLRMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TLRMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10577dXOa505a3f19f25843c4b10577c00">
              <SHORT-NAME>TLRSysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105788XOa505a3f19f25843c4b10578700">
                  <SHORT-NAME>TLRSysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TLRSysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105794XOa505a3f19f25843c4b10579300">
              <SHORT-NAME>TLRWarning</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10579fXOa505a3f19f25843c4b10579e00">
                  <SHORT-NAME>TLRWarning</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TLRWarning</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b814XOa505a3f19f25843c4b11b81300">
              <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b81fXOa505a3f19f25843c4b11b81e00">
                  <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSBtmNosRSSI</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b842XOa505a3f19f25843c4b11b84100">
              <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b84dXOa505a3f19f25843c4b11b84c00">
                  <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSSnsrID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b82bXOa505a3f19f25843c4b11b82a00">
              <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b836XOa505a3f19f25843c4b11b83500">
                  <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSSnsrIDLoctn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b7e6XOa505a3f19f25843c4b11b7e500">
              <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b7f1XOa505a3f19f25843c4b11b7f000">
                  <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSSnsrRSSI</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b870XOa505a3f19f25843c4b11b86f00">
              <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b87bXOa505a3f19f25843c4b11b87a00">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSSnsrRdoFrqcCtr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b859XOa505a3f19f25843c4b11b85800">
              <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b864XOa505a3f19f25843c4b11b86300">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSSnsrRdoFrqcCtrLoctn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b7cfXOa505a3f19f25843c4b11b7ce00">
              <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b7daXOa505a3f19f25843c4b11b7d900">
                  <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TPMSWntrMdA</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111639XOa505a3f19f25843c4b11163800">
              <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111644XOa505a3f19f25843c4b11164300">
                  <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TQRTMTqReq_N</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111650XOa505a3f19f25843c4b11164f00">
              <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11165bXOa505a3f19f25843c4b11165a00">
                  <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TRCEMTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111667XOa505a3f19f25843c4b11166600">
              <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111672XOa505a3f19f25843c4b11167100">
                  <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TRCTqDmdSTC_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1057c2XOa505a3f19f25843c4b1057c100">
              <SHORT-NAME>TSRSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1057cdXOa505a3f19f25843c4b1057cc00">
                  <SHORT-NAME>TSRSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TSRSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108cbfXOa505a3f19f25843c4b108cbe00">
              <SHORT-NAME>TSRSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108ccaXOa505a3f19f25843c4b108cc900">
                  <SHORT-NAME>TSRSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TSRSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1057d9XOa505a3f19f25843c4b1057d800">
              <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1057e4XOa505a3f19f25843c4b1057e300">
                  <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TSRSwReqResp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1057f0XOa505a3f19f25843c4b1057ef00">
              <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1057fbXOa505a3f19f25843c4b1057fa00">
                  <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TSRTrgtBanSign</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105807XOa505a3f19f25843c4b10580600">
              <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105812XOa505a3f19f25843c4b10581100">
                  <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TSRTrgtWarnSign</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11167eXOa505a3f19f25843c4b11167d00">
              <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111689XOa505a3f19f25843c4b11168800">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TZXEMMaxTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111695XOa505a3f19f25843c4b11169400">
              <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1116a0XOa505a3f19f25843c4b11169f00">
                  <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TZXEMTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1225ecXOa505a3f19f25843c4b1225eb00">
              <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1225f7XOa505a3f19f25843c4b1225f600">
                  <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TemSnsrHdwrFltPrst</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b112ddaXOa505a3f19f25843c4b112dd900">
              <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b112de5XOa505a3f19f25843c4b112de400">
                  <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TgtParkingFavorite</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1057abXOa505a3f19f25843c4b1057aa00">
              <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1057b6XOa505a3f19f25843c4b1057b500">
                  <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ToEPSMsgChlg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1116acXOa505a3f19f25843c4b1116ab00">
              <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1116b7XOa505a3f19f25843c4b1116b600">
                  <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TqCtrlStat_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b120b63XOa505a3f19f25843c4b120b6200">
              <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b120b6eXOa505a3f19f25843c4b120b6d00">
                  <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrdtnKeyBtnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b120b35XOa505a3f19f25843c4b120b3400">
              <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b120b40XOa505a3f19f25843c4b120b3f00">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrdtnSmrtKyFindCarSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11ce17XOa505a3f19f25843c4b11ce1600">
              <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11ce22XOa505a3f19f25843c4b11ce2100">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrdtnSmrtKyLckSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b120b4cXOa505a3f19f25843c4b120b4b00">
              <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b120b57XOa505a3f19f25843c4b120b5600">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrdtnSmrtKyLdspcSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11ce00XOa505a3f19f25843c4b11cdff00">
              <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11ce0bXOa505a3f19f25843c4b11ce0a00">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrdtnSmrtKyUnlckSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd52XOa505a3f19f25843c4b10fd5100">
              <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd5dXOa505a3f19f25843c4b10fd5c00">
                  <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfGreenLghtActn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f2b8XOa505a3f19f25843c4b10f2b700">
              <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f2c3XOa505a3f19f25843c4b10f2c200">
                  <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcForbidDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f2cfXOa505a3f19f25843c4b10f2ce00">
              <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f2daXOa505a3f19f25843c4b10f2d900">
                  <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcInfoSignDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f148XOa505a3f19f25843c4b10f14700">
              <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f153XOa505a3f19f25843c4b10f15200">
                  <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcJamRngNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f15fXOa505a3f19f25843c4b10f15e00">
              <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f16aXOa505a3f19f25843c4b10f16900">
                  <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcLghtFuctionSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc9aXOa505a3f19f25843c4b10fc9900">
              <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fca5XOa505a3f19f25843c4b10fca400">
                  <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcLghtFuctionSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fcb1XOa505a3f19f25843c4b10fcb000">
              <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fcbcXOa505a3f19f25843c4b10fcbb00">
                  <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcLghtStSp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fcc8XOa505a3f19f25843c4b10fcc700">
              <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fcd3XOa505a3f19f25843c4b10fcd200">
                  <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdForbidDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fcdfXOa505a3f19f25843c4b10fcde00">
              <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fceaXOa505a3f19f25843c4b10fce900">
                  <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdForbidSign</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fcf6XOa505a3f19f25843c4b10fcf500">
              <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd01XOa505a3f19f25843c4b10fd0000">
                  <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdInfoSign</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd0dXOa505a3f19f25843c4b10fd0c00">
              <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd18XOa505a3f19f25843c4b10fd1700">
                  <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdInfoSignDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd24XOa505a3f19f25843c4b10fd2300">
              <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd2fXOa505a3f19f25843c4b10fd2e00">
                  <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdWrnngSign</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fd3bXOa505a3f19f25843c4b10fd3a00">
              <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fd46XOa505a3f19f25843c4b10fd4500">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrfcMrgdWrnngSignDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1230c9XOa505a3f19f25843c4b1230c800">
              <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1230d4XOa505a3f19f25843c4b1230d300">
                  <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrgtCndSpdReqCamr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c62fXOa505a3f19f25843c4b11c62e00">
              <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c63aXOa505a3f19f25843c4b11c63900">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TrgtSpdSrcSts_IPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e0a9XOa505a3f19f25843c4b10e0a800">
              <SHORT-NAME>TripCnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e0b4XOa505a3f19f25843c4b10e0b300">
                  <SHORT-NAME>TripCnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TripCnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e0d7XOa505a3f19f25843c4b10e0d600">
              <SHORT-NAME>TripCntResetReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e0e2XOa505a3f19f25843c4b10e0e100">
                  <SHORT-NAME>TripCntResetReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/TripCntResetReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1116c3XOa505a3f19f25843c4b1116c200">
              <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1116ceXOa505a3f19f25843c4b1116cd00">
                  <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VDCSlipCtrlSts_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108cedXOa505a3f19f25843c4b108cec00">
              <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108cf8XOa505a3f19f25843c4b108cf700">
                  <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshDay</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d04XOa505a3f19f25843c4b108d0300">
              <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d0fXOa505a3f19f25843c4b108d0e00">
                  <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshHr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d1bXOa505a3f19f25843c4b108d1a00">
              <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d26XOa505a3f19f25843c4b108d2500">
                  <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshMins</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d32XOa505a3f19f25843c4b108d3100">
              <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d3dXOa505a3f19f25843c4b108d3c00">
                  <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshMth</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d49XOa505a3f19f25843c4b108d4800">
              <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d54XOa505a3f19f25843c4b108d5300">
                  <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshSec</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d60XOa505a3f19f25843c4b108d5f00">
              <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d6bXOa505a3f19f25843c4b108d6a00">
                  <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/VehTiPblshYear</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c4c7XOa505a3f19f25843c4b10c4c600">
              <SHORT-NAME>Veldownsigma</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c4d2XOa505a3f19f25843c4b10c4d100">
                  <SHORT-NAME>Veldownsigma</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/Veldownsigma</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10c4deXOa505a3f19f25843c4b10c4dd00">
              <SHORT-NAME>Veleastsigma</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10c4e9XOa505a3f19f25843c4b10c4e800">
