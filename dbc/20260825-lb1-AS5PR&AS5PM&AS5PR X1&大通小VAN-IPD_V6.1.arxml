                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSOCReqAI</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>185</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3072db00">
                  <SHORT-NAME>X160</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSHapticWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>187</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3072c000">
                  <SHORT-NAME>X159</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSAdoWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>189</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30721e00">
                  <SHORT-NAME>X155</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVolmcSnsrSetngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30734700">
                  <SHORT-NAME>X164</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSDstrctnHptWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>201</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30732c00">
                  <SHORT-NAME>X163</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSDstrctnAdoWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>203</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30731100">
                  <SHORT-NAME>X162</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSDstrctnSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>205</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3072f600">
                  <SHORT-NAME>X161</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>207</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30740400">
                  <SHORT-NAME>X171</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMInnrDschrgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>212</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3073b300">
                  <SHORT-NAME>X168</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOMSSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>214</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30725400">
                  <SHORT-NAME>TrgtSOCReqAIV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSOCReqAIV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>215</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30739800">
                  <SHORT-NAME>X167</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOMSBabyCareReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>241</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30737d00">
                  <SHORT-NAME>X166</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOmsGesDetSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>243</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30736200">
                  <SHORT-NAME>X165</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOmsIlbRemSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>245</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3072a500">
                  <SHORT-NAME>X158</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSSPLotSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>247</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30741f00">
                  <SHORT-NAME>X172</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITakeKeyOutRmndrPersSetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>322</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3073e900">
                  <SHORT-NAME>X170</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICmftUnlckPersSetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>324</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3073ce00">
                  <SHORT-NAME>X169</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICmftLckPersSetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>326</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e5e8XOa505a3f19f25843c4b32e5e700">
              <SHORT-NAME>ICB_100ms_PDU221</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/IPDPowerFailSwReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU221/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e68200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVPMapRutMgIDtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e5fa00">
                  <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPowerFailSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>97</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e61600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRACtlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e66700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IShwrmComprEnbReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>125</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e63100">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISrfOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>140</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e5e8xOa505a3f19f25843c4b32e64c00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRainClsWndAppMsg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32d065XOa505a3f19f25843c4b32d06400">
              <SHORT-NAME>ICB_100ms_PDU82</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU82/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32d065xOa505a3f19f25843c4b32d07700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSysSelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32183bXOa505a3f19f25843c4b32183a00">
              <SHORT-NAME>ICB_500ms_PDU229</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_500ms_PDU229/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.5</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32183bxOa505a3f19f25843c4b32184d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavCtryCode_ISO</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e259XOa505a3f19f25843c4b32e25800">
              <SHORT-NAME>ICB_Sporadic_PDU67</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_Sporadic_PDU67/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e259xOa505a3f19f25843c4b32e26b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIdentityChlg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3090faXOa505a3f19f25843c4b3090f900">
              <SHORT-NAME>ICB_ZONE_100ms_PDU00</SHORT-NAME>
              <LENGTH>32</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/AltngChrgCrntReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/DschrgTrgtSOCVal</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_ZONE_100ms_PDU00/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30915e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCPCBTemp1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30917900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCPCBTemp2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30919400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCPCBTemp3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b3091af00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCPCBTemp4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b3091ca00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCPCBTemp5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b3091e500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICCThermalCoolingLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30912800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMV2XEnEnbReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30910c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IElecPwrDistbnScene</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30920000">
                  <SHORT-NAME>AltngChrgCrntReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAltngChrgCrntReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3090faxOa505a3f19f25843c4b30914300">
                  <SHORT-NAME>DschrgTrgtSOCVal</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDschrgTrgtSOCVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b351940XOa505a3f19f25843c4b35193f00">
              <SHORT-NAME>IMM_50ms_PDU02</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DMSSts_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrAbnormBehvor_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrDstcnStsINST_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrDstcnSts_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrFtgLvlINST_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrFtgLvl_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrGazeRgn_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/DrvrPrst_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/EyeOnRoad_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/ILBRReq_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/IMM_50ms_Group02_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/IMM_50ms_Group02_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/OMSSts_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/SpfngDet_IMM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU02/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a9f00">
                  <SHORT-NAME>IMM_50ms_Group02_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351ab900">
                  <SHORT-NAME>IMM_50ms_Group02_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c3f00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b35199b00">
                  <SHORT-NAME>DrvrDstcnStsINST_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnStsINST_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b35198100">
                  <SHORT-NAME>ILBRReq_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILBRReq_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b3519e900">
                  <SHORT-NAME>DrvrAbnormBehvor_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormBehvor_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b3519cf00">
                  <SHORT-NAME>DMSSts_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c5900">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a8500">
                  <SHORT-NAME>SpfngDet_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpfngDet_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a0300">
                  <SHORT-NAME>DrvrDstcnSts_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnSts_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b35195400">
                  <SHORT-NAME>OMSSts_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOMSSts_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b3519b500">
                  <SHORT-NAME>DrvrFtgLvlINST_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvlINST_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c7300">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a1d00">
                  <SHORT-NAME>DrvrFtgLvl_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvl_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a5100">
                  <SHORT-NAME>DrvrPrst_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrPrst_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a3700">
                  <SHORT-NAME>DrvrGazeRgn_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrGazeRgn_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c8d00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351b6f00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenStatus_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351ca700">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351cc100">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>80</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c0b00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRightEyeOccludeStatus_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>82</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351bd700">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILeftEyeOccludeStatus_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351a6b00">
                  <SHORT-NAME>EyeOnRoad_IMM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOnRoad_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351b0700">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgConf_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351aed00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnConf_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351ad300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormConf_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351b2100">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazepitch_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351b3b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazeyaw_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351b5500">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenDegree_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xN200000119f8c72e8e06300800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved143</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xN200000119f8c72e8e0631f800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved151</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xN200000119f8c72e8e0633c100">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved159</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351cdb00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>163</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351bf100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMouthOccludeStatus_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>165</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351c2500">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IYawnStatus_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351cf500">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>175</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351d0f00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b351d2900">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351940xOa505a3f19f25843c4b35196e00">
                  <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIMM_50ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3578ceXOa505a3f19f25843c4b3578cd00">
              <SHORT-NAME>IMM_50ms_PDU04</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IMM_50ms_PDU04/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3578cexOa505a3f19f25843c4b3578e100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSCameraFps_IMM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30d12eXOa505a3f19f25843c4b30d12d00">
              <SHORT-NAME>IPD_100ms_PDU03</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjExistPrblty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjId</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjLatRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjLongtRltvDist</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjLongtRltvSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjRisk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjSyncCtr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU03/ACCDetObjTyp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d19200">
                  <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLongtRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d1e300">
                  <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjSyncCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d1ad00">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLongtRltvSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d1c800">
                  <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjRisk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d1fe00">
                  <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d17700">
                  <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLatRltvDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d14000">
                  <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjExistPrblty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30d12exOa505a3f19f25843c4b30d15c00">
                  <SHORT-NAME>ACCDetObjId</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjId</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32f2afXOa505a3f19f25843c4b32f2ae00">
              <SHORT-NAME>IPD_100ms_PDU124</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU124/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f2c100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdBtnDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f39a00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdReDst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f2f800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f34900">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f36400">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstR</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f2dd00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdCndNotSt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f37f00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstTostDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f3b500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f31300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDst360Req</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>116</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f2afxOa505a3f19f25843c4b32f32e00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstBtnDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32fb31XOa505a3f19f25843c4b32fb3000">
              <SHORT-NAME>IPD_100ms_PDU127</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU127/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU127/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32fb31xOa505a3f19f25843c4b32fb5f00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpedRegulaModSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>180</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32fb31xOa505a3f19f25843c4b32fb4300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRADSSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>373</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32f719XOa505a3f19f25843c4b32f71800">
              <SHORT-NAME>IPD_100ms_PDU128</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU128/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32f719xOa505a3f19f25843c4b32f72b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDSysKeyPsAvlbl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32fb8fXOa505a3f19f25843c4b32fb8e00">
              <SHORT-NAME>IPD_100ms_PDU130</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU130/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU130/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU130/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32fb8fxOa505a3f19f25843c4b32fba100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRASysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32fb8fxOa505a3f19f25843c4b32fbd800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHWPEMStsForEdr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>124</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32fb8fxOa505a3f19f25843c4b32fbbd00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHWPEMSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e396XOa505a3f19f25843c4b32e39500">
              <SHORT-NAME>IPD_100ms_PDU16</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU16/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e41200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDThermalWrnngLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e3f700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPMICTemp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e3dc00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPCBTemp2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e3c100">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPCBTemp1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e42d00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDSOCTemp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e396xOa505a3f19f25843c4b32e3a500">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDAurixTemp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b354437XOa505a3f19f25843c4b35443600">
              <SHORT-NAME>IPD_100ms_PDU35</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/EORWarningEvtSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/HORWarningEvtSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/PosALCFailed</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/SLIFAudWrnng_IPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/SLIFSts_IPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/SLIFUpdtIndResp_IPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/SLIFWrnngMdResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/SpdAstSysTrgtSpd_IPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/TrgtSpdSrcSts_IPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU35/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3546ef00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITSRTrgtWarnSign</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35468300">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdAstSysTrgtSpd_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3546d400">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITSRTrgtBanSign</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>77</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3546b900">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITSRSwReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>97</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35466800">
                  <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFSts_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>100</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35469e00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITSRSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35448200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrF1FltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>244</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35446700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysADASFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>247</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35444c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSSPLotSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>249</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3544ee00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrRFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>252</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35449d00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrF3FltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>255</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3544d300">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrFRSFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>260</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3544b800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrFLSFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>263</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35452400">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrRRSFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>268</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35450900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysAVCamrRLSFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>271</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3545ab00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysHDAVMCamrRFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>276</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35457500">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysHDAVMCamrFFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>279</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3545c600">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysHDAVMCamrRHFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>284</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35459000">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysHDAVMCamrLHFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>287</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3547c300">
                  <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFWrnngMdResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>289</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3545e100">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysLFSDAFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>292</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35453f00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysFDRFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>295</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35481100">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSpdSrcSts_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>297</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3545fc00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysLHRDAFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>300</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35461700">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysRFSDAFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>303</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3547f700">
                  <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFAudWrnng_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>304</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35482b00">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFUpdtInd_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>305</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35455a00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysFLIDARFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>308</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35463200">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysRHRDAFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>311</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35464d00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotSysUSSFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>319</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35472500">
                  <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHORWarningEvtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>338</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35470a00">
                  <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEORWarningEvtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>341</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35474000">
                  <SHORT-NAME>PosALCFailed</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPosALCFailed</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>351</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3547a900">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFSysFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>355</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35475b00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISAMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>359</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b3547dd00">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFUpdtIndResp_IPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>361</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35477500">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISASysFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>364</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xOa505a3f19f25843c4b35478f00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISASysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>367</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b354437xN200000119f633c96cf5b51900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngSpdSwResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>375</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b322537XOa505a3f19f25843c4b32253600">
              <SHORT-NAME>IPD_100ms_PDU50</SHORT-NAME>
              <LENGTH>32</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU50/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322537xOa505a3f19f25843c4b32254900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCamrHeatCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>195</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e6f2XOa505a3f19f25843c4b32e6f100">
              <SHORT-NAME>IPD_100ms_PDU58</SHORT-NAME>
              <LENGTH>32</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU58/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e73b00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRAAlrWorDis</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e8eb00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreSpdLimtCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e8d000">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e75600">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITgtParkingFavorite</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e70400">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDWtrClntInltFlwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e89a00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDAVCamrHeatReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>72</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e72000">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDWtrClntInltTimeReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>109</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e84900">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetNumResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>115</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e87f00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITJAICAMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>123</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e86400">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetPercResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e7a700">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCStsSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>129</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e78c00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSpdLimtSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>131</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e7dd00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLimitManualSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>137</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e81300">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>139</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e7c200">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdlVcCmdSwReqDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>141</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e77100">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADAudioSWSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e82e00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtMdMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>147</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e7f800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e90600">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngEndDis</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e6f2xOa505a3f19f25843c4b32e8b500">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCOvTSuppresCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32ca0bXOa505a3f19f25843c4b32ca0a00">
              <SHORT-NAME>IPD_100ms_PDU61</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/ESSDspCmd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/NOACitySysMsg</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/NOAQukChgSwDspCmd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/NOPSysMsg</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X137</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X138</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X139</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X140</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X141</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X142</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X143</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X144</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X145</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X146</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X147</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X148</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_100ms_PDU61/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cbb300">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReqToICM_HPP</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ca1d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSAdoWrnngDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb1100">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPFnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb2c00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPInBmtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb9800">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSCurToEndPntDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ca3900">
                  <SHORT-NAME>ESSDspCmd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc1f00">
                  <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOACitySysMsg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ca5400">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ccf700">
                  <SHORT-NAME>NOPSysMsg</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysMsg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cbce00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRInHMI</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc3a00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOADistDecMsg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc0400">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssSwResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>66</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd2d00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssMesg</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb7d00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IJAMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cec100">
                  <SHORT-NAME>X140</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDetourMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cdb400">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutDircnSelResult</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc8b00">
                  <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAQukChgSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd4800">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ca6f00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>92</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce7100">
                  <SHORT-NAME>X137</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEBSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cadb00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfrDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>97</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cac000">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32caa500">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMRUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>101</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ca8a00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMLUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc7000">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOALaneSetDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>105</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cc5500">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAETCSetDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>107</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cbe900">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>109</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32caf600">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ccc100">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPCitySwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ccdc00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSwDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>116</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cca600">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAReportSetDspCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cef700">
                  <SHORT-NAME>X142</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>121</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cedc00">
                  <SHORT-NAME>X141</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>123</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cea600">
                  <SHORT-NAME>X139</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEBWarngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>125</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd1200">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssConfrmSwDscmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf6300">
                  <SHORT-NAME>X146</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>129</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf4800">
                  <SHORT-NAME>X145</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRSUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>131</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf2d00">
                  <SHORT-NAME>X144</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRMRUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>133</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf1200">
                  <SHORT-NAME>X143</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRMLUSSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce0500">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutFRCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>136</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cdea00">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutFLParllSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>137</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cdcf00">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutFLCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>138</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd9900">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutBkRCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>139</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd7e00">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutBkLCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>140</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cd6300">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutBkCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>141</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb6200">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPOnRoutSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>142</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cb4700">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPMapBuildSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf7e00">
                  <SHORT-NAME>X147</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngDirAvlSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>145</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32cf9900">
                  <SHORT-NAME>X148</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngDirSwResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>147</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce5600">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngSlotFindSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>149</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce3b00">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutFrtCrsSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>150</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce2000">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngOutFRParllSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32ca0bxOa505a3f19f25843c4b32ce8c00">
                  <SHORT-NAME>X138</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEBSwResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>158</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32a64fXOa505a3f19f25843c4b32a64e00">
              <SHORT-NAME>IPD_10ms_PDU59</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_10ms_PDU59/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_10ms_PDU59/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_10ms_PDU59/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a64fxOa505a3f19f25843c4b32a66100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAParkInOffsetType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a64fxOa505a3f19f25843c4b32a67d00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPARemShifGear</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a64fxOa505a3f19f25843c4b32a69800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b31e355XOa505a3f19f25843c4b31e35400">
              <SHORT-NAME>IPD_20ms_PDU43</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU43/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e3cc00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e3e700">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e40200">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e36700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqToqVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e41d00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e3b100">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e39600">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts_SCS</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e43800">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e45300">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e46e00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31e355xOa505a3f19f25843c4b31e38300">
                  <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group43</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3290f3XOa505a3f19f25843c4b3290f200">
              <SHORT-NAME>IPD_20ms_PDU60</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU60/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3292e500">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32930000">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3291d700">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngRLaneSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32931b00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32933500">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32915000">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSToqReqVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3291a100">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosY</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32916b00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatAzmth</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3291f200">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDirInd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3292af00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotTkovMsgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32927900">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysSts_ZPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3292ca00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPrkgDstCtrlSwResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32913500">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32910700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32918600">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosX</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3291bc00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngLLaneSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32936900">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>105</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32924300">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>108</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32922800">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32939d00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>112</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32920d00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDrvrTkovReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32938300">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>116</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32929400">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngslottype</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3293b700">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>124</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32925e00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3293d100">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b3293eb00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32940500">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32941f00">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3290f3xOa505a3f19f25843c4b32912200">
                  <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group60</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b34370fXOa505a3f19f25843c4b34370e00">
              <SHORT-NAME>IPD_20ms_PDU64</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU64/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34372100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34375000">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3437d700">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSDrvrReqSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3437a100">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34382800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngVelMax</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34380d00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngTrgtDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34378600">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34385e00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34376b00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3437f200">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngPrflReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34384300">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSReqSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3437bc00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFnMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34387900">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34389400">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3438af00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3438ca00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b3438e500">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34390000">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34391b00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34393600">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34395100">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34370fxOa505a3f19f25843c4b34373d00">
                  <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group64</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b357697XOa505a3f19f25843c4b35769600">
              <SHORT-NAME>IPD_20ms_PDU67</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_20ms_PDU67/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3576f100">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35784300">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35785d00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved15</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35770b00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved23</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35772500">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved31</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35773f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved39</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35775900">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved47</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35777300">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved55</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35778d00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3577a700">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved71</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3576aa00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3576d700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>80</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3577c100">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved95</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3577db00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved103</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3577f500">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved111</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35780f00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved119</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b35782900">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved127</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b357697xOa505a3f19f25843c4b3576c400">
                  <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group67</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e97bXOa505a3f19f25843c4b32e97a00">
              <SHORT-NAME>IPD_50ms_PDU14</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU14/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea5e00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea7900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea9400">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eaaf00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eaca00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eae500">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb0000">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb1b00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32e98d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32e9bc00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReqToICM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb3600">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>72</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32e9d700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSProgressBar</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea0d00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWLSRObsRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32e9f200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWLSFObsRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea4300">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWRSRObsRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>91</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32ea2800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWRSFObsRng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb5100">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb6c00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eb8700">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32eba200">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e97bxOa505a3f19f25843c4b32e9a900">
                  <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group14</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b315dd9XOa505a3f19f25843c4b315dd800">
              <SHORT-NAME>IPD_50ms_PDU49</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/APAEnRunReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved2</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved3</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved4</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved5</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/IPD_50ms_Group49_Reserved6</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/KeepPwrRsnIPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/LADSAFnInd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU49/SysPwrMdCtrl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e3600">
                  <SHORT-NAME>IPD_50ms_Group49_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e5100">
                  <SHORT-NAME>IPD_50ms_Group49_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315dec00">
                  <SHORT-NAME>KeepPwrRsnIPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeepPwrRsnIPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315ea200">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e1b00">
                  <SHORT-NAME>SysPwrMdCtrl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMdCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e6c00">
                  <SHORT-NAME>APAEnRunReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnRunReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315ebd00">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315ed800">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315ef300">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e8700">
                  <SHORT-NAME>LADSAFnInd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSAFnInd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315f0e00">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315f2900">
                  <SHORT-NAME>IPD_50ms_Group49_Reserved6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315dd9xOa505a3f19f25843c4b315e0800">
                  <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group49</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3218bbXOa505a3f19f25843c4b3218ba00">
              <SHORT-NAME>IPD_50ms_PDU62</SHORT-NAME>
              <LENGTH>32</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_50ms_PDU62/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a6300">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistL1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a7e00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistL2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3219c100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedL1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a9900">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistL3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321ab400">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistR1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3219dc00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedL2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321acf00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistR2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321aea00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDistR3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3219f700">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedL3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>77</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b0500">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightL1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32191f00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceL1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>102</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b2000">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightL2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32193a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceL2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>118</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b3b00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightL3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32195500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceL3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>134</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b5600">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightR1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32197000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceR1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>150</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b7100">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightR2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32198b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceR2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>166</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321b8c00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockHeightR3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>175</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3219a600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockConfidenceR3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>182</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3218e900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadHeightL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b3218cd00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPrvOutSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>194</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a1200">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedR1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>198</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b32190400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadHeightR</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>207</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a4800">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedR3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>219</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3218bbxOa505a3f19f25843c4b321a2d00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadProfileShockDetectedR2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>223</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3558e5XOa505a3f19f25843c4b3558e400">
              <SHORT-NAME>IPD_BKBCANFD_EvtInfo</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_BKBCANFD_EvtInfo/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b3558f700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35591300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35592e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35594900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>199</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35596400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>263</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35597f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>327</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b35599a00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>391</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3558e5xOa505a3f19f25843c4b3559b500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>455</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b315fcaXOa505a3f19f25843c4b315fc900">
              <SHORT-NAME>IPD_Sporadic_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgCheckSum</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgOVS</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgSGW</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgSequenceCounter</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgTime</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgTimeDomain</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgType</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU01/SyncMsgreserved</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                        <REPETITION-PERIOD>
                          <VALUE>0</VALUE>
                        </REPETITION-PERIOD>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31609300">
                  <SHORT-NAME>SyncMsgType</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b315fdd00">
                  <SHORT-NAME>SyncMsgCheckSum</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgCheckSum</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31604200">
                  <SHORT-NAME>SyncMsgSequenceCounter</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgSequenceCounter</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31607800">
                  <SHORT-NAME>SyncMsgTimeDomain</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgTimeDomain</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31600c00">
                  <SHORT-NAME>SyncMsgOVS</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgOVS</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31602700">
                  <SHORT-NAME>SyncMsgSGW</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgSGW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b3160ae00">
                  <SHORT-NAME>SyncMsgreserved</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgreserved</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b31605d00">
                  <SHORT-NAME>SyncMsgTime</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgTime</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b315fcaxOa505a3f19f25843c4b315ff900">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_Sporadic_TimeSync_Group</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e4bcXOa505a3f19f25843c4b32e4bb00">
              <SHORT-NAME>IPD_Sporadic_PDU13</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU13/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>3</NUMBER-OF-REPETITIONS>
                        <REPETITION-PERIOD>
                          <VALUE>0.15</VALUE>
                        </REPETITION-PERIOD>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e4bcxOa505a3f19f25843c4b32e4ce00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDIdentityResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32e45dXOa505a3f19f25843c4b32e45c00">
              <SHORT-NAME>IPD_Sporadic_PDU35</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU35/AIParkngRespICB</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/IPD_Sporadic_PDU35/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                        <REPETITION-PERIOD>
                          <VALUE>0.02</VALUE>
                        </REPETITION-PERIOD>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e45dxOa505a3f19f25843c4b32e46f00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDComKeyEnbResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>3</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32e45dxOa505a3f19f25843c4b32e48b00">
                  <SHORT-NAME>AIParkngRespICB</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngRespICB</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f470aXOa505a3f19f25843c4b2f470900">
              <SHORT-NAME>LHZCU_100ms_PDU14</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU14/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f47a400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDSP_RrWinInhbSwtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>10</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f478900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDSP_RrWinInhbSwtFlt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f471c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBCMOdoReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f47da00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLampSwStsMntry_CPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f475300">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoSecy</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f476e00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IImmoSubModTCAuthnRunSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f47bf00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IImmoSubModSACAuthnRunSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f473800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDRDircnIndLampSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f470axOa505a3f19f25843c4b2f47f500">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITemSnsrHdwrFltPrst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f4825XOa505a3f19f25843c4b2f482400">
              <SHORT-NAME>LHZCU_100ms_PDU15</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/FrtWindShldSfcTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/FrtWindShldSurndHmdty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/FrtWindShldSurndTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU15/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f496100">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmtKeyAuthnMnModRunSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f491000">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHtdFrtLftVwWndActSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f485300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILOtsdMirActSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f48da00">
                  <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSurndHmdty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f486e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISolarStrngLSide</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f488900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISolarStrngRSide</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f48f500">
                  <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSurndTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f48bf00">
                  <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSfcTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f492b00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISolarStrngLSideV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f494600">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISolarStrngRSideV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f48a400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDKBLERst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4825xOa505a3f19f25843c4b2f483700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWiperSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f4991XOa505a3f19f25843c4b2f499000">
              <SHORT-NAME>LHZCU_100ms_PDU16</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/HUDFwdLkngAmbtLghtLvl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/HUDLghtSnsrHdwrFltPrst</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/HUDRLSAmbtLghtLvl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/HmdtySnsrHdwrFltPrst</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
