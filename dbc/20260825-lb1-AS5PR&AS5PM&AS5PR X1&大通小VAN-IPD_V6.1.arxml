                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCSysFltSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b09600">
                          <SHORT-NAME>ACCSysFltSts_SCS</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCSysFltSts_SCS_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts_SCS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38afb500">
                          <SHORT-NAME>ACCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCSysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ba5700">
                          <SHORT-NAME>ACCTJAMdSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCTJAMdSwDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882b200">
                          <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882c100">
                          <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ba6800">
                          <SHORT-NAME>ACCTotWhlToqReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCTotWhlToqReqSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ba7900">
                          <SHORT-NAME>ACCTotWhlToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ACCTotWhlToqReqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c7e300">
                          <SHORT-NAME>ADS_SpdAstSysTrgtSpdV_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ADS_SpdAstSysTrgtSpdV_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c7d300">
                          <SHORT-NAME>ADS_SpdAstSysTrgtSpd_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ADS_SpdAstSysTrgtSpd_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1b300">
                          <SHORT-NAME>AEBBrkJerkLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBBrkJerkLvlReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBBrkJerkLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1c200">
                          <SHORT-NAME>AEBDclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBDclReqSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1a400">
                          <SHORT-NAME>AEBDclReqToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBDclReqToqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1d100">
                          <SHORT-NAME>AEBDclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBDclReqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1e000">
                          <SHORT-NAME>AEBHydBrkAstLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBHydBrkAstLvlReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBHydBrkAstLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1ef00">
                          <SHORT-NAME>AEBPrflReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBPrflReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBPrflReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b1fe00">
                          <SHORT-NAME>AEBSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBSysFltSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b20d00">
                          <SHORT-NAME>AEBSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AEBSysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f634e8e3d26a4900">
                          <SHORT-NAME>AIParkngSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AIParkngSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849fd00">
                          <SHORT-NAME>AIPilotSysSaBrInh_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AIPilotSysSaBrInh_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPilotSysSaBrInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384a0c00">
                          <SHORT-NAME>AIPilotSysSaBrSts_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AIPilotSysSaBrSts_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPilotSysSaBrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38afc400">
                          <SHORT-NAME>AIPkgAPASCSAcclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AIPkgAPASCSAcclReqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPkgAPASCSAcclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2829d00">
                          <SHORT-NAME>APACmdEPSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APACmdEPSSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACmdEPSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131edc200">
                          <SHORT-NAME>APACrpSpdReqVal_IPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APACrpSpdReqVal_IPD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACrpSpdReqVal_IPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38afd300">
                          <SHORT-NAME>APAEPBOPReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAEPBOPReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38afe200">
                          <SHORT-NAME>APAEPBOPReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAEPBOPReqV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38971100">
                          <SHORT-NAME>APAEnRunReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAEnRunReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnRunReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882df00">
                          <SHORT-NAME>APAEnToqReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAEnToqReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882ee00">
                          <SHORT-NAME>APAEnToqReqVal_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAEnToqReqVal_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb282d100">
                          <SHORT-NAME>APAF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAF_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131edf600">
                          <SHORT-NAME>APARevrDrgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APARevrDrgReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPARevrDrgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38aff100">
                          <SHORT-NAME>APASCSAcclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSAcclReqSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSAcclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38830c00">
                          <SHORT-NAME>APASCSBrkFnMd_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSBrkFnMd_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFnMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882fd00">
                          <SHORT-NAME>APASCSBrkFn_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSBrkFn_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38831b00">
                          <SHORT-NAME>APASCSDrvrReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSDrvrReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSDrvrReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38832a00">
                          <SHORT-NAME>APASCSParkngPrflReq_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSParkngPrflReq_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngPrflReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38833900">
                          <SHORT-NAME>APASCSParkngTrgtDist_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSParkngTrgtDist_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngTrgtDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38834800">
                          <SHORT-NAME>APASCSParkngVelMax_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSParkngVelMax_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngVelMax</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38835700">
                          <SHORT-NAME>APASCSReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCSReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2830500">
                          <SHORT-NAME>APASCUReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCUReqSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2833900">
                          <SHORT-NAME>APASCUReqStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASCUReqStsV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2836d00">
                          <SHORT-NAME>APAShifterPosReqd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAShifterPosReqd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb283a100">
                          <SHORT-NAME>APAShifterPosReqdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAShifterPosReqdV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38751000">
                          <SHORT-NAME>APASts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APASts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ee2a00">
                          <SHORT-NAME>APAToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAToqReqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131eefa00">
                          <SHORT-NAME>APATotWhlToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APATotWhlToqReqVal_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATotWhlToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb283d500">
                          <SHORT-NAME>APATrgtEPSStrgWhlAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APATrgtEPSStrgWhlAng_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATrgtEPSStrgWhlAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ee5e00">
                          <SHORT-NAME>APAVCUReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/APAVCUReqSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVCUReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383d6c00">
                          <SHORT-NAME>AccelOvrd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AccelOvrd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelOvrd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38620b00">
                          <SHORT-NAME>AirCtrlrHVILClsd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AirCtrlrHVILClsd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38621a00">
                          <SHORT-NAME>AirCtrlrHVILClsdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AirCtrlrHVILClsdV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38958b00">
                          <SHORT-NAME>AutoChrgngMngmnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutoChrgngMngmnt_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoChrgngMngmnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890ea00">
                          <SHORT-NAME>AutocTrCmddGear_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutocTrCmddGear_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrCmddGear_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38813200">
                          <SHORT-NAME>AutocTrGearShftDircnF_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutocTrGearShftDircnF_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircnF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38812300">
                          <SHORT-NAME>AutocTrGearShftDircn_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutocTrGearShftDircn_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38af2e00">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysEmgcBrkReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38af3d00">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysEmgcBrkReqV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b00000">
                          <SHORT-NAME>AutodDrvngSysFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysFlrSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b00f00">
                          <SHORT-NAME>AutodDrvngSysFlrStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysFlrStsV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b01e00">
                          <SHORT-NAME>AutodDrvngSysMdReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysMdReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b02d00">
                          <SHORT-NAME>AutodDrvngSysMdReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysMdReqV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b03c00">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysSCSDrvOffReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b04b00">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysSCSDrvOffReqV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b05a00">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysSCSSdslReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b06900">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysSCSSdslReqV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38751f00">
                          <SHORT-NAME>AutodDrvngSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38373100">
                          <SHORT-NAME>AutodDrvngSysStsPT_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysStsPT_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsPT</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388e9000">
                          <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384a1b00">
                          <SHORT-NAME>AutodDrvngToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AutodDrvngToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngToqReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b1f45a00">
                          <SHORT-NAME>AuxBatUnAssembled_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/AuxBatUnAssembled_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAuxBatUnAssembled</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38742f00">
                          <SHORT-NAME>BMSOfbdChrgrSktVol</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BMSOfbdChrgrSktVol_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVol</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38743e00">
                          <SHORT-NAME>BMSOfbdChrgrSktVolV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BMSOfbdChrgrSktVolV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVolV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38744d00">
                          <SHORT-NAME>BMSOffBdChrgrPlugOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BMSOffBdChrgrPlugOn_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38745c00">
                          <SHORT-NAME>BMSOffBdChrgrPlugOnV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BMSOffBdChrgrPlugOnV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOnV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad3000">
                          <SHORT-NAME>BarPrsAbs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BarPrsAbs_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad4200">
                          <SHORT-NAME>BarPrsAbsOBD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BarPrsAbsOBD_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsOBD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad5400">
                          <SHORT-NAME>BarPrsAbsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BarPrsAbsV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3beee00">
                          <SHORT-NAME>CCUActiveWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUActiveWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUActiveWkup</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38622900">
                          <SHORT-NAME>CCUClntFlowReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUClntFlowReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUClntFlowReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3bf2500">
                          <SHORT-NAME>CCUOnbdChrgrMaxChrgPwr_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUOnbdChrgrMaxChrgPwr_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrMaxChrgPwr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3bf9300">
                          <SHORT-NAME>CCUOnbdChrgrPlugOnV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUOnbdChrgrPlugOnV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOnV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3bf5c00">
                          <SHORT-NAME>CCUOnbdChrgrPlugOn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUOnbdChrgrPlugOn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38623800">
                          <SHORT-NAME>CCUOnbdChrgrSktEleccLckEnable</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUOnbdChrgrSktEleccLckEnable_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSktEleccLckEnable</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3bfca00">
                          <SHORT-NAME>CCUOnbdChrgrSpRsn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCUOnbdChrgrSpRsn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSpRsn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381a7d00">
                          <SHORT-NAME>CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3828ce00">
                          <SHORT-NAME>CCU_100ms_Group02_CRC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_CRC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3828dd00">
                          <SHORT-NAME>CCU_100ms_Group02_RC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_RC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b382ce800">
                          <SHORT-NAME>CCU_100ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b382cf700">
                          <SHORT-NAME>CCU_100ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b382d0600">
                          <SHORT-NAME>CCU_100ms_Group02_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b382d1500">
                          <SHORT-NAME>CCU_100ms_Group02_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group02_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3beb700">
                          <SHORT-NAME>CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group07</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c00100">
                          <SHORT-NAME>CCU_100ms_Group07_CRC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_CRC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c03800">
                          <SHORT-NAME>CCU_100ms_Group07_RC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_RC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c0a600">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved10_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved10_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c0dd00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved11_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved11_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c06f00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved1_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved1_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c11400">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved2_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved2_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c14b00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved3_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved3_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c18200">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved4_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved4_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c1bf00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved5_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved5_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c1f600">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved6_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved6_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c22d00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved7_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved7_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c26400">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved8_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved8_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c29b00">
                          <SHORT-NAME>CCU_100ms_Group07_Reserved9_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group07_Reserved9_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3861de00">
                          <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group11</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3861ed00">
                          <SHORT-NAME>CCU_100ms_Group11_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3861fc00">
                          <SHORT-NAME>CCU_100ms_Group11_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdc300">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce2600">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved10_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce3100">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved11_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce3c00">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved12_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce4700">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved13_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce5200">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved14_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdce00">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdd900">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cde400">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdef00">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdfa00">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce0500">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce1000">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved8_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce1b00">
                          <SHORT-NAME>CCU_100ms_Group11_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_Group11_Reserved9_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389a9500">
                          <SHORT-NAME>ClOpenReqA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ClOpenReqA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClOpenReqA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38985b00">
                          <SHORT-NAME>CluActTorq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CluActTorq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICluActTorq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac1f00">
                          <SHORT-NAME>CrkshftNonTrRegdCmddToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CrkshftNonTrRegdCmddToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICrkshftNonTrRegdCmddToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38935100">
                          <SHORT-NAME>CstRgtnBrkLgtReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CstRgtnBrkLgtReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICstRgtnBrkLgtReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38936000">
                          <SHORT-NAME>CstRgtnBrkLgtReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CstRgtnBrkLgtReqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICstRgtnBrkLgtReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38650d00">
                          <SHORT-NAME>DMSSts_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DMSSts_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38814100">
                          <SHORT-NAME>DrvlnToqStabSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvlnToqStabSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvlnToqStabSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b6600">
                          <SHORT-NAME>DrvrReqFrtAxleWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrReqFrtAxleWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b7500">
                          <SHORT-NAME>DrvrReqFrtAxleWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrReqFrtAxleWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b8400">
                          <SHORT-NAME>DrvrReqRrAxleWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrReqRrAxleWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b9300">
                          <SHORT-NAME>DrvrReqRrAxleWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrReqRrAxleWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890f900">
                          <SHORT-NAME>DrvrShftCtrlReqDndIO</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrShftCtrlReqDndIO_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlReqDndIO</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38910800">
                          <SHORT-NAME>DrvrShftCtrlTrgtGear_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DrvrShftCtrlTrgtGear_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlTrgtGear_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c1ed00">
                          <SHORT-NAME>DschrgOptMaxPwr_DschrgOptMaxPwr_DschrgOptMaxPwr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/DschrgOptMaxPwr_DschrgOptMaxPwr_DschrgOptMaxPwr_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDschrgOptMaxPwr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389a8600">
                          <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_010ms_Group00</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_Group00_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389aef00">
                          <SHORT-NAME>ECM_010ms_Group00_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_Group00_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389afe00">
                          <SHORT-NAME>ECM_010ms_Group00_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_Group00_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf0b00">
                          <SHORT-NAME>ECM_010ms_Group00_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_Group00_Reserved39_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf1a00">
                          <SHORT-NAME>ECM_010ms_Group00_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_Group00_Reserved63_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38902700">
                          <SHORT-NAME>ECM_020ms_PDU03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_020ms_PDU03_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38903600">
                          <SHORT-NAME>ECM_020ms_PDU03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_020ms_PDU03_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38838400">
                          <SHORT-NAME>ECM_25ms_Group36_CRC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_CRC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3880f600">
                          <SHORT-NAME>ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_25ms_Group36</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38839300">
                          <SHORT-NAME>ECM_25ms_Group36_RC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_RC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38845000">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3884b300">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved10_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38845b00">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38846600">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38847100">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38847c00">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38848700">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38849200">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38849d00">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved8_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3884a800">
                          <SHORT-NAME>ECM_25ms_Group36_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_Group36_Reserved9_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad1e00">
                          <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_500ms_group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_500ms_group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38adf600">
                          <SHORT-NAME>ECM_500ms_group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_500ms_group02_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ae0800">
                          <SHORT-NAME>ECM_500ms_group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_500ms_group02_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ae2c00">
                          <SHORT-NAME>ECM_500ms_group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_500ms_group02_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388f8200">
                          <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_ZONE_020ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_020ms_Group03_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38905400">
                          <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_020ms_Group03_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38906300">
                          <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_020ms_Group03_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38799900">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_CRC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_CRC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38791200">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_ZONE_050ms_Group09</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3879a800">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_RC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_RC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b387bfd00">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b387c0c00">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b387c1b00">
                          <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_Group09_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38792100">
                          <SHORT-NAME>ECODrvngSpdRutA_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECODrvngSpdRutA_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECODrvngSpdRutA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874f200">
                          <SHORT-NAME>EDUClntTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EDUClntTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUClntTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383f4000">
                          <SHORT-NAME>EDUClntTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EDUClntTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUClntTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f3b412cac5717a00">
                          <SHORT-NAME>EDUOilTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EDUOilTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f3b412cac570c400">
                          <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EDUOilTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c80300">
                          <SHORT-NAME>ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSysSts_IPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbeac700">
                          <SHORT-NAME>EPMCurEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPMCurEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMCurEstdCapct</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbeafe00">
                          <SHORT-NAME>EPMMaxEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPMMaxEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMMaxEstdCapct</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbeb3500">
                          <SHORT-NAME>EPMOprtMd_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPMOprtMd_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMOprtMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c3100">
                          <SHORT-NAME>EPTAPARevrDrgReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTAPARevrDrgReqResp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAPARevrDrgReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895f400">
                          <SHORT-NAME>EPTAccelActuPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTAccelActuPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelActuPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38960300">
                          <SHORT-NAME>EPTAccelActuPosV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTAccelActuPosV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelActuPosV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38961200">
                          <SHORT-NAME>EPTAccelEfctvPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTAccelEfctvPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelEfctvPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38962100">
                          <SHORT-NAME>EPTBrkPdlDscrtInptSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTBrkPdlDscrtInptSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTBrkPdlDscrtInptSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38963000">
                          <SHORT-NAME>EPTBrkPdlDscrtInptStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTBrkPdlDscrtInptStsV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTBrkPdlDscrtInptStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383e9800">
                          <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTClntPumpSta_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTClntPumpSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38963f00">
                          <SHORT-NAME>EPTCrkAbotd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTCrkAbotd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTCrkAbotd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383ef500">
                          <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTElecWtrPumpActuSpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTElecWtrPumpActuSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38965d00">
                          <SHORT-NAME>EPTHVDCDCMdReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTHVDCDCMdReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTHVDCDCMdReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38959a00">
                          <SHORT-NAME>EPTHVEmgcPwrOffReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTHVEmgcPwrOffReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTHVEmgcPwrOffReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895a900">
                          <SHORT-NAME>EPTMainRelayDrvReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTMainRelayDrvReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTMainRelayDrvReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894f500">
                          <SHORT-NAME>EPTRdy</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTRdy_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTRdy</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894e600">
                          <SHORT-NAME>EPTRdyV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTRdyV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTRdyV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384ea000">
                          <SHORT-NAME>EPTSecyAxleInptShaftSpdV_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTSecyAxleInptShaftSpdV_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTSecyAxleInptShaftSpdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384e9100">
                          <SHORT-NAME>EPTSecyAxleInptShaftSpd_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTSecyAxleInptShaftSpd_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTSecyAxleInptShaftSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38964e00">
                          <SHORT-NAME>EPTStCmdOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTStCmdOn_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTStCmdOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbeba300">
                          <SHORT-NAME>EPTToqCustSetngReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTToqCustSetngReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTToqCustSetngReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbeb6c00">
                          <SHORT-NAME>EPTToqCustSetngReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTToqCustSetngReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTToqCustSetngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383b3d00">
                          <SHORT-NAME>EPTTrInptShaftSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrInptShaftSpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383b4c00">
                          <SHORT-NAME>EPTTrInptShaftSpdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrInptShaftSpdV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384ebe00">
                          <SHORT-NAME>EPTTrInptShaftSpdV_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrInptShaftSpdV_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpdV_R</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b384eaf00">
                          <SHORT-NAME>EPTTrInptShaftSpd_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrInptShaftSpd_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpd_R</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849b200">
                          <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotMaxAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMaxAvlblToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849a300">
                          <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotMaxAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMaxAvlblToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849d000">
                          <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotMinAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMinAvlblToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849c100">
                          <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotMinAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMinAvlblToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849ee00">
                          <SHORT-NAME>EPTTrOtptShaftTotToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3849df00">
                          <SHORT-NAME>EPTTrOtptShaftTotToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EPTTrOtptShaftTotToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38624700">
                          <SHORT-NAME>ESSPTCHVILSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESSPTCHVILSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38625600">
                          <SHORT-NAME>ESSPTCHVILStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESSPTCHVILStsV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38742000">
                          <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IESS_100ms_Group58</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38746b00">
                          <SHORT-NAME>ESS_100ms_Group58_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38747a00">
                          <SHORT-NAME>ESS_100ms_Group58_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38748900">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38749800">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874a700">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874b600">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874c500">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874d400">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3874e300">
                          <SHORT-NAME>ESS_100ms_Group58_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_Group58_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38793000">
                          <SHORT-NAME>EcoDrvngAIO_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EcoDrvngAIO_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngAIO</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38793f00">
                          <SHORT-NAME>EcoDrvngDspStsGearShftIndSts_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EcoDrvngDspStsGearShftIndSts_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsGearShftIndSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38794e00">
                          <SHORT-NAME>EcoDrvngDspStsRcmndFwdGear_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EcoDrvngDspStsRcmndFwdGear_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsRcmndFwdGear</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895b800">
                          <SHORT-NAME>ElecMotEmgcShutDwn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ElecMotEmgcShutDwn_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IElecMotEmgcShutDwn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38924300">
                          <SHORT-NAME>EleccLckCtrlResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EleccLckCtrlResp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEleccLckCtrlResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388f9100">
                          <SHORT-NAME>EnASSFrngDet</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnASSFrngDet_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFrngDet</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388fa000">
                          <SHORT-NAME>EnASSFuelReqdOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnASSFuelReqdOn_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFuelReqdOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38904500">
                          <SHORT-NAME>EnASSSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnASSSta_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388faf00">
                          <SHORT-NAME>EnASSStallDet</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnASSStallDet_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSStallDet</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b0d00">
                          <SHORT-NAME>EnActuStdyStaToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnActuStdyStaToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b1c00">
                          <SHORT-NAME>EnActuStdyStaToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnActuStdyStaToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388fbe00">
                          <SHORT-NAME>EnAutoSpNotProb</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnAutoSpNotProb_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnAutoSpNotProb</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b5800">
                          <SHORT-NAME>EnCCMd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnCCMd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCCMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad6600">
                          <SHORT-NAME>EnClntTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnClntTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad7800">
                          <SHORT-NAME>EnClntTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnClntTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac7900">
                          <SHORT-NAME>EnComFlrRducdPwrCmdd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnComFlrRducdPwrCmdd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnComFlrRducdPwrCmdd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389aa400">
                          <SHORT-NAME>EnCtrlrRunCrkTrmlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnCtrlrRunCrkTrmlSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCtrlrRunCrkTrmlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac8800">
                          <SHORT-NAME>EnDclFuelCutOffAld</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnDclFuelCutOffAld_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffAld</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac9700">
                          <SHORT-NAME>EnDclFuelCutOffReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnDclFuelCutOffReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38aca600">
                          <SHORT-NAME>EnDclFuelCutOffSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnDclFuelCutOffSta_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac2e00">
                          <SHORT-NAME>EnFuelCutA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnFuelCutA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelCutA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac3d00">
                          <SHORT-NAME>EnFuelRcvrySpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnFuelRcvrySpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelRcvrySpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38acb500">
                          <SHORT-NAME>EnHybVehStaOvrd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnHybVehStaOvrd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnHybVehStaOvrd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38acc400">
                          <SHORT-NAME>EnIdleCtrlA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnIdleCtrlA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38acd300">
                          <SHORT-NAME>EnIdleCtrlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnIdleCtrlSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad8a00">
                          <SHORT-NAME>EnIntkAirTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnIntkAirTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad9c00">
                          <SHORT-NAME>EnIntkAirTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnIntkAirTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ace200">
                          <SHORT-NAME>EnReqdStTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnReqdStTyp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnReqdStTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b2b00">
                          <SHORT-NAME>EnRunA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnRunA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnRunA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389ab300">
                          <SHORT-NAME>EnSpReqToTr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnSpReqToTr_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpReqToTr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b3a00">
                          <SHORT-NAME>EnSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnSpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b4900">
                          <SHORT-NAME>EnSpdSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnSpdSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b96600">
                          <SHORT-NAME>EnStCtrlA_PICU_10ms_Group23_PICU_10ms_Group23_PICU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnStCtrlA_PICU_10ms_Group23_PICU_10ms_Group23_PICU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnStCtrlA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac4c00">
                          <SHORT-NAME>EnSynRdy</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnSynRdy_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSynRdy</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38acf100">
                          <SHORT-NAME>EnSysDsbld</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnSysDsbld_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSysDsbld</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b9c000">
                          <SHORT-NAME>EnTestMdEnbReq_ECM_010ms_Group00_ECM_010ms_Group00_ECM_010ms_Group00</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnTestMdEnbReq_ECM_010ms_Group00_ECM_010ms_Group00_ECM_010ms_Group00_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnTestMdEnbReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388fcd00">
                          <SHORT-NAME>EnToqActuExtdRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqActuExtdRng_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388fdc00">
                          <SHORT-NAME>EnToqActuExtdRngV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqActuExtdRngV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388feb00">
                          <SHORT-NAME>EnToqDrvrReqdExtdRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqDrvrReqdExtdRng_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388ffa00">
                          <SHORT-NAME>EnToqDrvrReqdExtdRngV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqDrvrReqdExtdRngV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38796c00">
                          <SHORT-NAME>EnToqMaxExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqMaxExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38795d00">
                          <SHORT-NAME>EnToqMaxExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqMaxExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38798a00">
                          <SHORT-NAME>EnToqMinExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqMinExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38797b00">
                          <SHORT-NAME>EnToqMinExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqMinExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38900900">
                          <SHORT-NAME>EnToqRducnFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnToqRducnFlrSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqRducnFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38adae00">
                          <SHORT-NAME>EnWarmUpCycAch</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnWarmUpCycAch_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnWarmUpCycAch</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbec1100">
                          <SHORT-NAME>EnrgSplReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnrgSplReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReqRaw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbec4700">
                          <SHORT-NAME>EnrgSplReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnrgSplReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbebda00">
                          <SHORT-NAME>EnrgSplReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EnrgSplReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb5600">
                          <SHORT-NAME>EyeOffRoadDetnSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EyeOffRoadDetnSta_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb6700">
                          <SHORT-NAME>EyeOffRoadDetnStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/EyeOffRoadDetnStaV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b9cf00">
                          <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFVCM_20ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b9e000">
                          <SHORT-NAME>FVCM_20ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b9f100">
                          <SHORT-NAME>FVCM_20ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce5d00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce6800">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce7300">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce7e00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce8900">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce9400">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ce9f00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved7_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ceaa00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_Group02_Reserved8_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38925200">
                          <SHORT-NAME>FlbStrgFnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FlbStrgFnSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFlbStrgFnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38926100">
                          <SHORT-NAME>FlbStrgFnStsResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FlbStrgFnStsResp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFlbStrgFnStsResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388ba200">
                          <SHORT-NAME>FrtAxleActuWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FrtAxleActuWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bb100">
                          <SHORT-NAME>FrtAxleActuWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FrtAxleActuWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b0a500">
                          <SHORT-NAME>FrtCarGoNotfr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FrtCarGoNotfr_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38626500">
                          <SHORT-NAME>HVDCDCClntPumpPWMReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCDCClntPumpPWMReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCClntPumpPWMReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38627400">
                          <SHORT-NAME>HVDCDCHdwrFlr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCDCHdwrFlr_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCHdwrFlr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38628300">
                          <SHORT-NAME>HVDCDCIntnlFlr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCDCIntnlFlr_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCIntnlFlr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381a8c00">
                          <SHORT-NAME>HVDCDCSta_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCDCSta_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381a9b00">
                          <SHORT-NAME>HVDCDCTem_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCDCTem_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381aaa00">
                          <SHORT-NAME>HVDCHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3828bf00">
                          <SHORT-NAME>HVDCHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HVDCHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ba8a00">
                          <SHORT-NAME>HandOffStrgWhlDetnSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HandOffStrgWhlDetnSta_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ba9b00">
                          <SHORT-NAME>HandOffStrgWhlDetnStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HandOffStrgWhlDetnStaV_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38936f00">
                          <SHORT-NAME>HybAPAAvlbl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HybAPAAvlbl_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybAPAAvlbl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad0000">
                          <SHORT-NAME>HybEnSpdReqF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HybEnSpdReqF_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnSpdReqF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ad0f00">
                          <SHORT-NAME>HybEnStSpOvrd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/HybEnStSpOvrd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnStSpOvrd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ed8c00">
                          <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group05</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ee9200">
                          <SHORT-NAME>ICBAD_20ms_Group05_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131eec600">
                          <SHORT-NAME>ICBAD_20ms_Group05_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ef2e00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f10800">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved10_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f13c00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved11_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f17000">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved12_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f1a400">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved13_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f1d800">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved14_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f20c00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ef6200">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131ef9600">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131efca00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131effe00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f03200">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f06600">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved7_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f09a00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved8_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5e2186131f0ce00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group05_Reserved9_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38af1f00">
                          <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group07</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group07_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38af4c00">
                          <SHORT-NAME>ICBAD_20ms_Group07_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group07_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38af5b00">
                          <SHORT-NAME>ICBAD_20ms_Group07_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group07_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f4200">
                          <SHORT-NAME>ICBAD_20ms_Group07_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group07_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38750100">
                          <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group12</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38752e00">
                          <SHORT-NAME>ICBAD_20ms_Group12_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38753d00">
                          <SHORT-NAME>ICBAD_20ms_Group12_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c58d00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c59800">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c5a300">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c5ae00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c5b900">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c5c400">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group12_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2816300">
                          <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2840900">
                          <SHORT-NAME>ICBAD_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2843d00">
                          <SHORT-NAME>ICBAD_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2819900">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb281cd00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2820100">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2823500">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2826900">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group13_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38991e00">
                          <SHORT-NAME>ICBAD_20ms_Group15_CRC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_CRC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38372200">
                          <SHORT-NAME>ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group15</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38992d00">
                          <SHORT-NAME>ICBAD_20ms_Group15_RC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_RC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c2900">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c3400">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c3f00">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c4a00">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c5500">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c6000">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c6b00">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved7_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c7600">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved8_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389c8100">
                          <SHORT-NAME>ICBAD_20ms_Group15_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group15_Reserved9_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b19500">
                          <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group46</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group46_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b21c00">
                          <SHORT-NAME>ICBAD_20ms_Group46_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group46_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b22b00">
                          <SHORT-NAME>ICBAD_20ms_Group46_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group46_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f8400">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group46_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f8f00">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_Group46_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38824900">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_ZONE_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38829400">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882a300">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38852a00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38853500">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38854000">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38854b00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38855600">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38856100">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e067a8d00">
                          <SHORT-NAME>ICBVC_100ms_Group19_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbea9000">
                          <SHORT-NAME>ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_100ms_Group19</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e06862500">
                          <SHORT-NAME>ICBVC_100ms_Group19_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e067d9000">
                          <SHORT-NAME>ICBVC_100ms_Group19_Reserved21</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_Reserved21_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved21</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e06807300">
                          <SHORT-NAME>ICBVC_100ms_Group19_Reserved35</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_Reserved35_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved35</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e06834d00">
                          <SHORT-NAME>ICBVC_100ms_Group19_Reserved58</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_Group19_Reserved58_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved58</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3865dd00">
                          <SHORT-NAME>ICBVC_50ms_Group256_CRC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_CRC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3864fd00">
                          <SHORT-NAME>ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group256</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3865ed00">
                          <SHORT-NAME>ICBVC_50ms_Group256_RC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_RC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf4d00">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved100</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved100_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved100</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf4100">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved103_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf6500">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved111_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf7100">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved119_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf7d00">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved127_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf2900">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved85</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved85_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved85</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf3500">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved95_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bf5900">
                          <SHORT-NAME>ICBVC_50ms_Group256_Reserved96</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_Group256_Reserved96_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved96</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38baac00">
                          <SHORT-NAME>ILCActvnDircnDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ILCActvnDircnDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnDircnDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38babd00">
                          <SHORT-NAME>ILCActvnVelDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ILCActvnVelDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnVelDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bace00">
                          <SHORT-NAME>ILCSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ILCSwDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38badf00">
                          <SHORT-NAME>ILCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ILCSysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b385b7200">
                          <SHORT-NAME>IMU_SN_IMU_SN_IMU_SN</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IMU_SN_IMU_SN_IMU_SN_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMU_SN</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38922500">
                          <SHORT-NAME>IMU_Signal_status</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IMU_Signal_status_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMU_Signal_status</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdb2b98400">
                          <SHORT-NAME>IPDStsResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPDStsResp_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDStsResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b07800">
                          <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group43</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38993c00">
                          <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38994b00">
                          <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f4d00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f5800">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f6300">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f6e00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f7900">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group43_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3883a200">
                          <SHORT-NAME>IPD_20ms_Group64_CRC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_CRC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3882d000">
                          <SHORT-NAME>IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group64</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3883b100">
                          <SHORT-NAME>IPD_20ms_Group64_RC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_RC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38856c00">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3885cf00">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved10_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38857700">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38858200">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38858d00">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38859800">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3885a300">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3885ae00">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved7_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3885b900">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved8_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3885c400">
                          <SHORT-NAME>IPD_20ms_Group64_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group64_Reserved9_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc2c00">
                          <SHORT-NAME>IPD_20ms_Group67_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c7c300">
                          <SHORT-NAME>IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group67</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccbb00">
                          <SHORT-NAME>IPD_20ms_Group67_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc8f00">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved103_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc9a00">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved111_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cca500">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved119_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccb000">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved127_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccc600">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved15_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc3700">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved23_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc4200">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved31_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc4d00">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved39_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc5800">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved47_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc6300">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved55_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc6e00">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved63_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc7900">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved71_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cc8400">
                          <SHORT-NAME>IPD_20ms_Group67_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_Group67_Reserved95_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3896c600">
                          <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group49</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3896e400">
                          <SHORT-NAME>IPD_50ms_Group49_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_CRC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3896f300">
                          <SHORT-NAME>IPD_50ms_Group49_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_RC_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a94900">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved1_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a95400">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved2_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a95f00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved3_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a96a00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved4_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a97500">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved5_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a98000">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_Group49_Reserved6_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38301200">
                          <SHORT-NAME>IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_NKI_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38303000">
                          <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38302100">
                          <SHORT-NAME>IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38300300">
                          <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38307b00">
                          <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38306c00">
                          <SHORT-NAME>IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38305d00">
                          <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38308a00">
                          <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b382ff400">
                          <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38303f00">
                          <SHORT-NAME>IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_NOI_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38304e00">
                          <SHORT-NAME>IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_NWI_PTCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_PTCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38273800">
                          <SHORT-NAME>IgnOffTimeV_IgnOffTimeV_IgnOffTimeV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IgnOffTimeV_IgnOffTimeV_IgnOffTimeV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIgnOffTimeV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38287300">
                          <SHORT-NAME>IgnOffTime_IgnOffTime_IgnOffTime</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IgnOffTime_IgnOffTime_IgnOffTime_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIgnOffTime</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389ac200">
                          <SHORT-NAME>IntlckRelayAuth</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IntlckRelayAuth_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIntlckRelayAuth</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3896d500">
                          <SHORT-NAME>KeepPwrRsnIPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/KeepPwrRsnIPD_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeepPwrRsnIPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38a98b00">
                          <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSAFnInd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38baf000">
                          <SHORT-NAME>LDWAdoWrnngDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LDWAdoWrnngDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb0100">
                          <SHORT-NAME>LDWLKAAudReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LDWLKAAudReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAAudReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb1200">
                          <SHORT-NAME>LDWLKADspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LDWLKADspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKADspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb2300">
                          <SHORT-NAME>LDWLKAHptWrnngDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LDWLKAHptWrnngDspCmd_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb3400">
                          <SHORT-NAME>LDWSnstvtLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LDWSnstvtLvl_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bb4500">
                          <SHORT-NAME>LKADrvrTkovReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LKADrvrTkovReq_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKADrvrTkovReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38825800">
                          <SHORT-NAME>LKASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LKASysFltSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38826700">
                          <SHORT-NAME>LKASysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LKASysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b1f49000">
                          <SHORT-NAME>LVBMDisChrgMOSCtrl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBMDisChrgMOSCtrl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBMDisChrgMOSCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbec7d00">
                          <SHORT-NAME>LVBatChrgReqInhbt_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBatChrgReqInhbt_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatChrgReqInhbt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbecb300">
                          <SHORT-NAME>LVBatChrgReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBatChrgReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatChrgReqRaw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbece900">
                          <SHORT-NAME>LVBatEnrgLow_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBatEnrgLow_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatEnrgLow</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbed1f00">
                          <SHORT-NAME>LVBatEnrgSufct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBatEnrgSufct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatEnrgSufct</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbed5500">
                          <SHORT-NAME>LVBatSelfWakeupFlg_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/LVBatSelfWakeupFlg_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatSelfWakeupFlg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38937e00">
                          <SHORT-NAME>MaxAvlblTotWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/MaxAvlblTotWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38938d00">
                          <SHORT-NAME>MaxAvlblTotWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/MaxAvlblTotWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38939c00">
                          <SHORT-NAME>MinAvlblTotWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/MinAvlblTotWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893ab00">
                          <SHORT-NAME>MinAvlblTotWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/MinAvlblTotWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f8230bf8d45b9400">
                          <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NarwSpcAstSwSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarwSpcAstSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38927000">
                          <SHORT-NAME>OfbdChrgrNgtvSktTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OfbdChrgrNgtvSktTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOfbdChrgrNgtvSktTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38927f00">
                          <SHORT-NAME>OfbdChrgrNgtvSktTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OfbdChrgrNgtvSktTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOfbdChrgrNgtvSktTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c2d200">
                          <SHORT-NAME>OnBdChrgrAltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrAltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptCrnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c30900">
                          <SHORT-NAME>OnBdChrgrAltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrAltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptVol</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c34000">
                          <SHORT-NAME>OnBdChrgrCtrlPilotPWMDuty_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrCtrlPilotPWMDuty_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMDuty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c37700">
                          <SHORT-NAME>OnBdChrgrCtrlPilotPWMSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrCtrlPilotPWMSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381ac800">
                          <SHORT-NAME>OnBdChrgrHVILStsValV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrHVILStsValV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsValV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381ab900">
                          <SHORT-NAME>OnBdChrgrHVILStsVal_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrHVILStsVal_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c3ae00">
                          <SHORT-NAME>OnBdChrgrL1AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL1AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptCrnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c3e500">
                          <SHORT-NAME>OnBdChrgrL1AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL1AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptVol</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c41c00">
                          <SHORT-NAME>OnBdChrgrL2AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL2AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptCrnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c45300">
                          <SHORT-NAME>OnBdChrgrL2AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL2AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptVol</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c48a00">
                          <SHORT-NAME>OnBdChrgrL3AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL3AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptCrnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c4c100">
                          <SHORT-NAME>OnBdChrgrL3AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrL3AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptVol</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c4f800">
                          <SHORT-NAME>OnBdChrgrLastWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrLastWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrLastWkup</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c8a000">
                          <SHORT-NAME>OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrOptAltPwr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c52f00">
                          <SHORT-NAME>OnBdChrgrOtptVolV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrOtptVolV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrOtptVolV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38928e00">
                          <SHORT-NAME>OnBdChrgrSktElecLckSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrSktElecLckSta_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktElecLckSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38929d00">
                          <SHORT-NAME>OnBdChrgrSktElecLckStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrSktElecLckStaV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktElecLckStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892ac00">
                          <SHORT-NAME>OnBdChrgrSktPstvSnsrTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrSktPstvSnsrTem_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktPstvSnsrTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892bb00">
                          <SHORT-NAME>OnBdChrgrSktPstvSnsrTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrSktPstvSnsrTemV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktPstvSnsrTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c56600">
                          <SHORT-NAME>OnBdChrgrSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c59d00">
                          <SHORT-NAME>OnBdChrgrWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnBdChrgrWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrWkup</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c5d400">
                          <SHORT-NAME>OnbdChrgrAltrCrntInptHVCrntLmt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrAltrCrntInptHVCrntLmt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrAltrCrntInptHVCrntLmt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c60b00">
                          <SHORT-NAME>OnbdChrgrOpngMd_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrOpngMd_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOpngMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c64200">
                          <SHORT-NAME>OnbdChrgrOtptCrntV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrOtptCrntV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c67900">
                          <SHORT-NAME>OnbdChrgrOtptCrntVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrOtptCrntVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4ba3c6b000">
                          <SHORT-NAME>OnbdChrgrOtptVolVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrOtptVolVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptVolVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892ca00">
                          <SHORT-NAME>OnbdChrgrSktEleccLckEnable</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OnbdChrgrSktEleccLckEnable_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrSktEleccLckEnable</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38adc000">
                          <SHORT-NAME>OtsdAirTemPtEstd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OtsdAirTemPtEstd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38add200">
                          <SHORT-NAME>OtsdAirTemPtEstdMsk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OtsdAirTemPtEstdMsk_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdMsk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ade400">
                          <SHORT-NAME>OtsdAirTemPtEstdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/OtsdAirTemPtEstdV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381ae600">
                          <SHORT-NAME>PDUHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PDUHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b381ad700">
                          <SHORT-NAME>PDUHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PDUHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839c600">
                          <SHORT-NAME>PEUMotADampTrqCmdd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotADampTrqCmdd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotADampTrqCmdd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f7d0600db2ba2500">
                          <SHORT-NAME>PEUMotAMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotAMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAMdAch</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839d500">
                          <SHORT-NAME>PEUMotASpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotASpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839f300">
                          <SHORT-NAME>PEUMotASpdSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotASpdSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839e400">
                          <SHORT-NAME>PEUMotASpdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotASpdV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a0200">
                          <SHORT-NAME>PEUMotAToqAch</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotAToqAch_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAch</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a1100">
                          <SHORT-NAME>PEUMotAToqAchV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotAToqAchV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAchV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a2000">
                          <SHORT-NAME>PEUMotBDampTrqCmdd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBDampTrqCmdd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBDampTrqCmdd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f7d0600db2ba5c00">
                          <SHORT-NAME>PEUMotBMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBMdAch</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a2f00">
                          <SHORT-NAME>PEUMotBSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBSpd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a3e00">
                          <SHORT-NAME>PEUMotBSpdSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBSpdSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a4d00">
                          <SHORT-NAME>PEUMotBSpdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBSpdV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a5c00">
                          <SHORT-NAME>PEUMotBToqAch</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBToqAch_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAch</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383a6b00">
                          <SHORT-NAME>PEUMotBToqAchV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEUMotBToqAchV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAchV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38399900">
                          <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPEU_10ms_Group25</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839a800">
                          <SHORT-NAME>PEU_10ms_Group25_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3839b700">
                          <SHORT-NAME>PEU_10ms_Group25_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f1500">
                          <SHORT-NAME>PEU_10ms_Group25_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f8c72e8e06770300">
                          <SHORT-NAME>PEU_10ms_Group25_Reserved147</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_Reserved147_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved147</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389f3300">
                          <SHORT-NAME>PEU_10ms_Group25_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_Group25_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388ad000">
                          <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPICU_10ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388c0b00">
                          <SHORT-NAME>PICU_10ms_Group03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388c1a00">
                          <SHORT-NAME>PICU_10ms_Group03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388adf00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388aee00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388afd00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b0c00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b1b00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b2a00">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b3900">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b4800">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved8_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388b5700">
                          <SHORT-NAME>PICU_10ms_Group03_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group03_Reserved9_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38abf200">
                          <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPICU_10ms_Group23</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac0100">
                          <SHORT-NAME>PICU_10ms_Group23_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group23_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac1000">
                          <SHORT-NAME>PICU_10ms_Group23_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group23_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bfdd00">
                          <SHORT-NAME>PICU_10ms_Group23_Reserved18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_Group23_Reserved18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_Reserved18</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38934200">
                          <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPICU_20ms_Group11</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893ba00">
                          <SHORT-NAME>PICU_20ms_Group11_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893c900">
                          <SHORT-NAME>PICU_20ms_Group11_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38940500">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38941400">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38942300">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38943200">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38944100">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38945000">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38945f00">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38946e00">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved8_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38947d00">
                          <SHORT-NAME>PICU_20ms_Group11_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_Group11_Reserved9_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbed8b00">
                          <SHORT-NAME>PMDCSta_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PMDCSta_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPMDCSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38901800">
                          <SHORT-NAME>PropSysA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PropSysA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPropSysA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac5b00">
                          <SHORT-NAME>PtACCA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PtACCA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtACCA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383d7b00">
                          <SHORT-NAME>PtACCToqReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PtACCToqReqResp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtACCToqReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b385c5300">
                          <SHORT-NAME>PtAPASts_RZCU_10ms_Group24_RZCU_10ms_Group24_RZCU_10ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PtAPASts_RZCU_10ms_Group24_RZCU_10ms_Group24_RZCU_10ms_Group24_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtAPASts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3896a800">
                          <SHORT-NAME>PtAPAToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PtAPAToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtAPAToqReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bc000">
                          <SHORT-NAME>PtHVCntarReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PtHVCntarReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtHVCntarReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38966c00">
                          <SHORT-NAME>RVSEPTRdy</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RVSEPTRdy_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSEPTRdy</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ac6a00">
                          <SHORT-NAME>RVSEnRunning</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RVSEnRunning_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSEnRunning</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389ad100">
                          <SHORT-NAME>RVSPtCrkAbotd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RVSPtCrkAbotd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtCrkAbotd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389ae000">
                          <SHORT-NAME>RVSPtRunAbotd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RVSPtRunAbotd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtRunAbotd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38395d00">
                          <SHORT-NAME>RZCUIgnDiagSts_RZCUIgnDiagSts_RZCUIgnDiagSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCUIgnDiagSts_RZCUIgnDiagSts_RZCUIgnDiagSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCUIgnDiagSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38396c00">
                          <SHORT-NAME>RZCUIgnSts_RZCUIgnSts_RZCUIgnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCUIgnSts_RZCUIgnSts_RZCUIgnSts_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCUIgnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38921600">
                          <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_100ms_Group10</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38932400">
                          <SHORT-NAME>RZCU_100ms_Group10_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38933300">
                          <SHORT-NAME>RZCU_100ms_Group10_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892d900">
                          <SHORT-NAME>RZCU_100ms_Group10_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892e800">
                          <SHORT-NAME>RZCU_100ms_Group10_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3892f700">
                          <SHORT-NAME>RZCU_100ms_Group10_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38930600">
                          <SHORT-NAME>RZCU_100ms_Group10_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38931500">
                          <SHORT-NAME>RZCU_100ms_Group10_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_Group10_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38957c00">
                          <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38967b00">
                          <SHORT-NAME>RZCU_10ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38968a00">
                          <SHORT-NAME>RZCU_10ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895c700">
                          <SHORT-NAME>RZCU_10ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895d600">
                          <SHORT-NAME>RZCU_10ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3895e500">
                          <SHORT-NAME>RZCU_10ms_Group01_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group01_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383b2e00">
                          <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383b5b00">
                          <SHORT-NAME>RZCU_10ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group02_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383b6a00">
                          <SHORT-NAME>RZCU_10ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group02_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38680300">
                          <SHORT-NAME>RZCU_10ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group02_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3898e200">
                          <SHORT-NAME>RZCU_10ms_Group22_CRC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group22_CRC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3898f100">
                          <SHORT-NAME>RZCU_10ms_Group22_RC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group22_RC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38499400">
                          <SHORT-NAME>RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group22</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bfe800">
                          <SHORT-NAME>RZCU_10ms_Group22_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group22_Reserved47_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38bff300">
                          <SHORT-NAME>RZCU_10ms_Group22_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group22_Reserved95_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383d5d00">
                          <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group23</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383d8a00">
                          <SHORT-NAME>RZCU_10ms_Group23_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383d9900">
                          <SHORT-NAME>RZCU_10ms_Group23_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44de6400">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44eb3700">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved10_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44eca000">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved11_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44ee0900">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved12_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44ef7700">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved13_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44f0e800">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved14_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44f25100">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved15_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44dfd500">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e13e00">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e2a700">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e41500">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e58600">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e6ef00">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved7_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e85800">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved8_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44e9c600">
                          <SHORT-NAME>RZCU_10ms_Group23_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group23_Reserved9_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c2200">
                          <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group24</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c5e00">
                          <SHORT-NAME>RZCU_10ms_Group24_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c6d00">
                          <SHORT-NAME>RZCU_10ms_Group24_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38686c00">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38687700">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38688200">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38688d00">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38689800">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3868a300">
                          <SHORT-NAME>RZCU_10ms_Group24_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group24_Reserved6_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccd100">
                          <SHORT-NAME>RZCU_10ms_Group90_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdad00">
                          <SHORT-NAME>RZCU_10ms_Group90_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c79300">
                          <SHORT-NAME>RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_10ms_Group90</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd5500">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved103_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd6000">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved111_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd6b00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved119_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd7600">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved127_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd8100">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved135</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved135_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved135</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd8c00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved143</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved143_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved143</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cdb800">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved15_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd9700">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved151</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved151_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved151</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cda200">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved159</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved159_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved159</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccdc00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved23_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cce700">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved31_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccf200">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved39_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ccfd00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved47_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd0800">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved55_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd1300">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
