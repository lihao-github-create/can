                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved63_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd1e00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved71_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd2900">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved79_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd3f00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved83</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved83_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved83</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd3400">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved87</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved87_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved87</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38cd4a00">
                          <SHORT-NAME>RZCU_10ms_Group90_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_Group90_Reserved95_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38948c00">
                          <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_20ms_Group06</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38954000">
                          <SHORT-NAME>RZCU_20ms_Group06_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38954f00">
                          <SHORT-NAME>RZCU_20ms_Group06_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38949b00">
                          <SHORT-NAME>RZCU_20ms_Group06_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894aa00">
                          <SHORT-NAME>RZCU_20ms_Group06_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894b900">
                          <SHORT-NAME>RZCU_20ms_Group06_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894c800">
                          <SHORT-NAME>RZCU_20ms_Group06_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3894d700">
                          <SHORT-NAME>RZCU_20ms_Group06_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_Group06_Reserved5_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893d800">
                          <SHORT-NAME>RdundtHybCmddEnToqImmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RdundtHybCmddEnToqImmd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqImmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893e700">
                          <SHORT-NAME>RdundtHybCmddEnToqPrdtd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RdundtHybCmddEnToqPrdtd_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqPrdtd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3893f600">
                          <SHORT-NAME>RdundtHybCmddEnToqRespTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RdundtHybCmddEnToqRespTyp_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqRespTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389ba400">
                          <SHORT-NAME>ReAxleMaxAvlblWhlDrvTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ReAxleMaxAvlblWhlDrvTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b9500">
                          <SHORT-NAME>ReAxleMaxAvlblWhlDrvTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ReAxleMaxAvlblWhlDrvTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389bc200">
                          <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ReAxleMaxAvlblWhlRgtnTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389bb300">
                          <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ReAxleMaxAvlblWhlRgtnTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbedf700">
                          <SHORT-NAME>RgnLvReqFICMV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RgnLvReqFICMV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgnLvReqFICMV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbedc100">
                          <SHORT-NAME>RgnLvReqFICM_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RgnLvReqFICM_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgnLvReqFICM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38652d00">
                          <SHORT-NAME>RoadCrvtDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoadCrvtDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvtDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38651d00">
                          <SHORT-NAME>RoadCrvt_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoadCrvt_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38654d00">
                          <SHORT-NAME>RoadSlopeDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoadSlopeDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlopeDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38653d00">
                          <SHORT-NAME>RoadSlope_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoadSlope_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlope</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38655d00">
                          <SHORT-NAME>RoughRoaddetectionDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoughRoaddetectionDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetectionDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b389b6700">
                          <SHORT-NAME>RoughRoaddetection_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RoughRoaddetection_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetection</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bcf00">
                          <SHORT-NAME>RrAxleActuWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RrAxleActuWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bde00">
                          <SHORT-NAME>RrAxleActuWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RrAxleActuWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38908100">
                          <SHORT-NAME>SCUAPAUnderCtrlA_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SCUAPAUnderCtrlA_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUAPAUnderCtrlA_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38909000">
                          <SHORT-NAME>SCUDrvrIntrvnA_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SCUDrvrIntrvnA_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvrIntrvnA_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38313e00">
                          <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831e300">
                          <SHORT-NAME>SDM_20ms_Group03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831f200">
                          <SHORT-NAME>SDM_20ms_Group03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38314d00">
                          <SHORT-NAME>SDM_20ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38315c00">
                          <SHORT-NAME>SDM_20ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38316b00">
                          <SHORT-NAME>SDM_20ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38317a00">
                          <SHORT-NAME>SDM_20ms_Group03_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_Group03_Reserved4_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38656d00">
                          <SHORT-NAME>SWSCnfmSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSCnfmSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSCnfmSwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38657d00">
                          <SHORT-NAME>SWSLFnChngSwA_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSLFnChngSwA_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSLFnChngSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38658d00">
                          <SHORT-NAME>SWSPB1SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSPB1SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB1SwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38659d00">
                          <SHORT-NAME>SWSPB2SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSPB2SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB2SwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3865ad00">
                          <SHORT-NAME>SWSPB3SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSPB3SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB3SwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3865bd00">
                          <SHORT-NAME>SWSSelLSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSSelLSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelLSwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3865cd00">
                          <SHORT-NAME>SWSSelRSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SWSSelRSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelRSwStuckL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38970200">
                          <SHORT-NAME>SysPwrMdCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SysPwrMdCtrl_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMdCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38907200">
                          <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_020ms_PDU18</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38986a00">
                          <SHORT-NAME>TCM_020ms_PDU18_CRC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_CRC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38987900">
                          <SHORT-NAME>TCM_020ms_PDU18_RC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_RC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38988800">
                          <SHORT-NAME>TCM_020ms_PDU18_Reserve01_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_Reserve01_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve01</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38989700">
                          <SHORT-NAME>TCM_020ms_PDU18_Reserve02_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_Reserve02_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve02</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3898a600">
                          <SHORT-NAME>TCM_020ms_PDU18_Reserve03_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_Reserve03_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve03</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38909f00">
                          <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_025ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_Group02_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891da00">
                          <SHORT-NAME>TCM_025ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_Group02_Reserved1_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891e900">
                          <SHORT-NAME>TCM_025ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_Group02_Reserved2_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891f800">
                          <SHORT-NAME>TCM_025ms_Group02_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_Group02_Reserved3_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890cc00">
                          <SHORT-NAME>TCM_025ms_PDU02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU02_CRC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890db00">
                          <SHORT-NAME>TCM_025ms_PDU02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU02_RC_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3811d00">
                          <SHORT-NAME>TCM_025ms_PDU05_CRC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU05_CRC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3815300">
                          <SHORT-NAME>TCM_025ms_PDU05_RC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU05_RC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3818900">
                          <SHORT-NAME>TCM_025ms_PDU05_Reserve01_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU05_Reserve01_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_Reserve01</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b384ad00">
                          <SHORT-NAME>TCM_025ms_PDU20_CRC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_CRC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b384e300">
                          <SHORT-NAME>TCM_025ms_PDU20_RC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_RC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3851900">
                          <SHORT-NAME>TCM_025ms_PDU20_Reserve01_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_Reserve01_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve01</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3854f00">
                          <SHORT-NAME>TCM_025ms_PDU20_Reserve02_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_Reserve02_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve02</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3858500">
                          <SHORT-NAME>TCM_025ms_PDU20_Reserve03_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_Reserve03_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve03</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b385bb00">
                          <SHORT-NAME>TCM_025ms_PDU20_Reserve04_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_Reserve04_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve04</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3847600">
                          <SHORT-NAME>TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_025ms_PDU20</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b380e600">
                          <SHORT-NAME>TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_PTCAN_FrP05</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38827600">
                          <SHORT-NAME>TJAICASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TJAICASysFltSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITJAICASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38828500">
                          <SHORT-NAME>TJAICASysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TJAICASysSts_IPD_PTCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITJAICASysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bed00">
                          <SHORT-NAME>TotActuWhlToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TotActuWhlToq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b388bfc00">
                          <SHORT-NAME>TotActuWhlToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TotActuWhlToqV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b385f100">
                          <SHORT-NAME>TrACCToqReqResp_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrACCToqReqResp_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrACCToqReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3898b500">
                          <SHORT-NAME>TrAPACanclReq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrAPACanclReq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrAPACanclReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38ae1a00">
                          <SHORT-NAME>TrClThrmlProtnNotfn_ECM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrClThrmlProtnNotfn_ECM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrClThrmlProtnNotfn_ECM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38815f00">
                          <SHORT-NAME>TrCrkshftToqLdV_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrCrkshftToqLdV_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38815000">
                          <SHORT-NAME>TrCrkshftToqLd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrCrkshftToqLd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38911700">
                          <SHORT-NAME>TrCrpMdA_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrCrpMdA_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrpMdA_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38816e00">
                          <SHORT-NAME>TrCustSetngDspCmd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrCustSetngDspCmd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCustSetngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38914400">
                          <SHORT-NAME>TrEPBAppReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEPBAppReq_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEPBAppReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38817d00">
                          <SHORT-NAME>TrEnASSOvrd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEnASSOvrd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEnASSOvrd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38955e00">
                          <SHORT-NAME>TrEngdSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEngdSta_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38956d00">
                          <SHORT-NAME>TrEngdStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEngdStaV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38913500">
                          <SHORT-NAME>TrEngdStaV_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEngdStaV_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdStaV_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38912600">
                          <SHORT-NAME>TrEngdSta_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEngdSta_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdSta_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38951300">
                          <SHORT-NAME>TrEstdGear</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEstdGear_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGear</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38950400">
                          <SHORT-NAME>TrEstdGearV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEstdGearV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGearV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38916200">
                          <SHORT-NAME>TrEstdGearV_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEstdGearV_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGearV_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38915300">
                          <SHORT-NAME>TrEstdGear_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrEstdGear_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGear_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b381f500">
                          <SHORT-NAME>TrGearV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrGearV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGearV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b381bf00">
                          <SHORT-NAME>TrGear_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrGear_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGear</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3822b00">
                          <SHORT-NAME>TrImmdCrkshftToqReqVal_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrImmdCrkshftToqReqVal_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3826100">
                          <SHORT-NAME>TrImmdCrkshftToqRespTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrImmdCrkshftToqRespTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqRespTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38811400">
                          <SHORT-NAME>TrInptClStsV_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrInptClStsV_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClStsV_ICE</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38810500">
                          <SHORT-NAME>TrInptClSts_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrInptClSts_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClSts_ICE</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38917100">
                          <SHORT-NAME>TrIntnlSwPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrIntnlSwPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38918000">
                          <SHORT-NAME>TrIntnlSwPosV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrIntnlSwPosV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPosV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38818c00">
                          <SHORT-NAME>TrMinVolReq_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrMinVolReq_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrMinVolReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b3829700">
                          <SHORT-NAME>TrPrdtdCrkshftToqIntrvnTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrPrdtdCrkshftToqIntrvnTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqIntrvnTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f5902a13b382cd00">
                          <SHORT-NAME>TrPrdtdCrkshftToqReqV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrPrdtdCrkshftToqReqV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38918f00">
                          <SHORT-NAME>TrPrkPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrPrkPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38919e00">
                          <SHORT-NAME>TrPrkSysF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrPrkSysF_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkSysF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38819b00">
                          <SHORT-NAME>TrRngInhSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrRngInhSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrRngInhSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38952200">
                          <SHORT-NAME>TrShftLvrPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrShftLvrPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38953100">
                          <SHORT-NAME>TrShftLvrPosV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrShftLvrPosV_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPosV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890ae00">
                          <SHORT-NAME>TrShftLvrPosV_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrShftLvrPosV_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPosV_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3890bd00">
                          <SHORT-NAME>TrShftLvrPos_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrShftLvrPos_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPos_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891ad00">
                          <SHORT-NAME>TrShftPtrnASts_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrShftPtrnASts_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftPtrnASts_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891bc00">
                          <SHORT-NAME>TrTapUpTapDwnMdSts_TCM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrTapUpTapDwnMdSts_TCM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTapUpTapDwnMdSts_TCM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3891cb00">
                          <SHORT-NAME>TrTrgtShftLvrPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrTrgtShftLvrPos_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTrgtShftLvrPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3881aa00">
                          <SHORT-NAME>TrWrnngDsp_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TrWrnngDsp_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrWrnngDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c4000">
                          <SHORT-NAME>VCUAPAFltRsn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VCUAPAFltRsn_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUAPAFltRsn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b383c4f00">
                          <SHORT-NAME>VCUAPAUnderCtrlA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VCUAPAUnderCtrlA_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUAPAUnderCtrlA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38923400">
                          <SHORT-NAME>VCUCtrlS2Req</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VCUCtrlS2Req_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUCtrlS2Req</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38c7a300">
                          <SHORT-NAME>VCU_ISAOvSpdOvRd_RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VCU_ISAOvSpdOvRd_RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCU_ISAOvSpdOvRd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38befc00">
                          <SHORT-NAME>VMCTarReWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VMCTarReWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarReWhlTqMaxLmtV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b97500">
                          <SHORT-NAME>VMCTarReWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VMCTarReWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarReWhlTqMaxLmt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b99300">
                          <SHORT-NAME>VMCTarWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VMCTarWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarWhlTqMaxLmtV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b98400">
                          <SHORT-NAME>VMCTarWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VMCTarWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarWhlTqMaxLmt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831b600">
                          <SHORT-NAME>VSELatAccV_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VSELatAccV_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAccV_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831a700">
                          <SHORT-NAME>VSELatAcc_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VSELatAcc_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAcc_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831d400">
                          <SHORT-NAME>VSELongtAccV_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VSELongtAccV_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAccV_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3831c500">
                          <SHORT-NAME>VSELongtAcc_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VSELongtAcc_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAcc_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38319800">
                          <SHORT-NAME>VehDynYawRateV_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VehDynYawRateV_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRateV_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38318900">
                          <SHORT-NAME>VehDynYawRate_SDM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VehDynYawRate_SDM_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRate_SDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbee6300">
                          <SHORT-NAME>VehEnrgRdyLvlV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VehEnrgRdyLvlV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehEnrgRdyLvlV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xNa505a3f19f34f4acdbbee2d00">
                          <SHORT-NAME>VehEnrgRdyLvl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VehEnrgRdyLvl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehEnrgRdyLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38b8f800">
                          <SHORT-NAME>VehboardSetting_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/VehboardSetting_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehboardSetting</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                      </I-SIGNAL-TRIGGERINGS>
                      <PDU-TRIGGERINGS>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380b6f00">
                          <SHORT-NAME>BMS_ZONE_PTCANFD_100ms_Container02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/BMS_ZONE_PTCANFD_100ms_Container02_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/BMS_ZONE_PTCANFD_100ms_Container02</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380a9e00">
                          <SHORT-NAME>CCU_100ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_PDU02_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_CRC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_RC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group02_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCDCSta_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCDCTem_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrHVILStsValV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrHVILStsVal_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PDUHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PDUHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38123f00">
                          <SHORT-NAME>CCU_100ms_PDU04</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_PDU04_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU04</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DschrgOptMaxPwr_DschrgOptMaxPwr_DschrgOptMaxPwr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e3299c00">
                          <SHORT-NAME>CCU_100ms_PDU07</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_PDU07_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU07</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUActiveWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUOnbdChrgrMaxChrgPwr_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUOnbdChrgrPlugOnV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUOnbdChrgrPlugOn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUOnbdChrgrSpRsn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_CRC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_RC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved10_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved11_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved1_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved2_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved3_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved4_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved5_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved6_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved7_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved8_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group07_Reserved9_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrAltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrAltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrCtrlPilotPWMDuty_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrCtrlPilotPWMSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL1AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL1AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL2AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL2AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL3AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrL3AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrLastWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrOtptVolV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrAltrCrntInptHVCrntLmt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrOpngMd_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrOtptCrntV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrOtptCrntVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrOtptVolVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380e1200">
                          <SHORT-NAME>CCU_100ms_PDU11</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/CCU_100ms_PDU11_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU11</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AirCtrlrHVILClsd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AirCtrlrHVILClsdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUClntFlowReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCUOnbdChrgrSktEleccLckEnable</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CCU_100ms_Group11_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESSPTCHVILSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESSPTCHVILStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCDCClntPumpPWMReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCDCHdwrFlr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HVDCDCIntnlFlr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380e2900">
                          <SHORT-NAME>ECM_010ms_PDU00</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_010ms_PDU00_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_010ms_PDU00</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ClOpenReqA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_010ms_Group00</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_010ms_Group00_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_010ms_Group00_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_010ms_Group00_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_010ms_Group00_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnActuStdyStaToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnActuStdyStaToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnCCMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnCtrlrRunCrkTrmlSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnRunA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnSpReqToTr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnSpdSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnTestMdEnbReq_ECM_010ms_Group00_ECM_010ms_Group00_ECM_010ms_Group00</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IntlckRelayAuth</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RVSPtCrkAbotd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RVSPtRunAbotd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817f800">
                          <SHORT-NAME>ECM_100ms_PDU10</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_100ms_PDU10</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38174d00">
                          <SHORT-NAME>ECM_100ms_PDU11</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_100ms_PDU11_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_100ms_PDU11</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTClntPumpSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817d600">
                          <SHORT-NAME>ECM_100ms_PDU12</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_100ms_PDU12</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38136e00">
                          <SHORT-NAME>ECM_25ms_PDU36</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_25ms_PDU36_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_25ms_PDU36</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutocTrGearShftDircnF_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutocTrGearShftDircn_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvlnToqStabSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_CRC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_RC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_25ms_Group36_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrCrkshftToqLdV_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrCrkshftToqLd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrCustSetngDspCmd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEnASSOvrd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrInptClStsV_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrInptClSts_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrMinVolReq_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrRngInhSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrWrnngDsp_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380dcd00">
                          <SHORT-NAME>ECM_500ms_PDU14</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_500ms_PDU14_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_500ms_PDU14</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BarPrsAbs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BarPrsAbsOBD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BarPrsAbsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_500ms_group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_500ms_group02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_500ms_group02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_500ms_group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnClntTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnClntTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnIntkAirTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnIntkAirTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnWarmUpCycAch</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OtsdAirTemPtEstd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OtsdAirTemPtEstdMsk</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OtsdAirTemPtEstdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrClThrmlProtnNotfn_ECM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817ed00">
                          <SHORT-NAME>ECM_ERCANFD_100ms_container10</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ERCANFD_100ms_container10_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/ECM_ERCANFD_100ms_container10</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38145c00">
                          <SHORT-NAME>ECM_ZONE_020ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_020ms_PDU03_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_020ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_020ms_PDU03_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_020ms_PDU03_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_020ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_020ms_Group03_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_020ms_Group03_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnASSFrngDet</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnASSFuelReqdOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnASSSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnASSStallDet</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnAutoSpNotProb</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqActuExtdRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqActuExtdRngV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqDrvrReqdExtdRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqDrvrReqdExtdRngV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqRducnFlrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PropSysA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3812e800">
                          <SHORT-NAME>ECM_ZONE_050ms_PDU09</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ECM_ZONE_050ms_PDU09_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_050ms_PDU09</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_CRC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_RC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_ZONE_050ms_Group09_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECODrvngSpdRutA_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EcoDrvngAIO_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EcoDrvngDspStsGearShftIndSts_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EcoDrvngDspStsRcmndFwdGear_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqMaxExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqMaxExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqMinExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnToqMinExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380b7a00">
                          <SHORT-NAME>ESS_100ms_PDU19</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU19</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380f6500">
                          <SHORT-NAME>ESS_100ms_PDU25</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU25</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3810e400">
                          <SHORT-NAME>ESS_100ms_PDU28</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU28</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380b8500">
                          <SHORT-NAME>ESS_100ms_PDU54</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU54</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38123400">
                          <SHORT-NAME>ESS_100ms_PDU58</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ESS_100ms_PDU58_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ESS_100ms_PDU58</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BMSOfbdChrgrSktVol</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BMSOfbdChrgrSktVolV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BMSOffBdChrgrPlugOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/BMSOffBdChrgrPlugOnV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_Group58_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817ca00">
                          <SHORT-NAME>FVCM_20ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/FVCM_20ms_PDU02_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_20ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjDistLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDrvrSelTrgtSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCGoNotfr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCSeldTrgtDistLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCTJAMdSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCTotWhlToqReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCTotWhlToqReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EyeOffRoadDetnSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EyeOffRoadDetnStaV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FVCM_20ms_Group02_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HandOffStrgWhlDetnSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HandOffStrgWhlDetnStaV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ILCActvnDircnDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ILCActvnVelDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ILCSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ILCSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LDWAdoWrnngDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LDWLKAAudReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LDWLKADspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LDWLKAHptWrnngDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LDWSnstvtLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LKADrvrTkovReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44534c00">
                          <SHORT-NAME>ICBAD_100ms_PDU29</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_100ms_PDU29_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU29</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AIParkngSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38109600">
                          <SHORT-NAME>ICBAD_100ms_PDU36</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_100ms_PDU36_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU36</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPDStsResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/NarwSpcAstSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e31ee700">
                          <SHORT-NAME>ICBAD_20ms_PDU05</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU05_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU05</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APACrpSpdReqVal_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APARevrDrgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAToqReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APATotWhlToqReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAVCUReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group05_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3813f600">
                          <SHORT-NAME>ICBAD_20ms_PDU07</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU07_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCAccReqSts_CH</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCAccReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCGoReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCSdslReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AIPkgAPASCSAcclReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAEPBOPReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAEPBOPReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSAcclReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysEmgcBrkReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysEmgcBrkReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysFlrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysFlrStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysMdReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysMdReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysSCSDrvOffReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysSCSDrvOffReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysSCSSdslReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysSCSSdslReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group07_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group07_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group07_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817bf00">
                          <SHORT-NAME>ICBAD_20ms_PDU12</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU12_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group12_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e31e7100">
                          <SHORT-NAME>ICBAD_20ms_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU13_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APACmdEPSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCUReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCUReqStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAShifterPosReqd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAShifterPosReqdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APATrgtEPSStrgWhlAng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group13_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f44440d00">
                          <SHORT-NAME>ICBAD_20ms_PDU15</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU15_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU15</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDclReqSts_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCOtptShaftTotToqReqSts_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCOtptShaftTotToqReqVal_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngSysStsPT_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_CRC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_RC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group15_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38115800">
                          <SHORT-NAME>ICBAD_20ms_PDU46</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_20ms_PDU46_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBBrkJerkLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBDclReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBDclReqToqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBDclReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBHydBrkAstLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBPrflReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AEBSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group46</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group46_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group46_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group46_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_20ms_Group46_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3813a500">
                          <SHORT-NAME>ICBAD_ZONE_20ms_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBAD_ZONE_20ms_PDU13_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LKASysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LKASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TJAICASysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TJAICASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38176400">
                          <SHORT-NAME>ICBVC_100ms_PDU19</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_100ms_PDU19_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU19</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AuxBatUnAssembled_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPMCurEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPMMaxEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPMOprtMd_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTToqCustSetngReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTToqCustSetngReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnrgSplReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnrgSplReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnrgSplReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_Reserved21</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_Reserved35</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_100ms_Group19_Reserved58</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBMDisChrgMOSCtrl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBatChrgReqInhbt_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBatChrgReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBatEnrgLow_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBatEnrgSufct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LVBatSelfWakeupFlg_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PMDCSta_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RgnLvReqFICMV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RgnLvReqFICM_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VehEnrgRdyLvlV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VehEnrgRdyLvl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380c1500">
                          <SHORT-NAME>ICBVC_500ms_PDU67</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_500ms_PDU67_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_500ms_PDU67</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IgnOffTimeV_IgnOffTimeV_IgnOffTimeV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IgnOffTime_IgnOffTime_IgnOffTime</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3818c000">
                          <SHORT-NAME>ICBVC_50ms_PDU256</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/ICBVC_50ms_PDU256_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU256</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DMSSts_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_CRC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_RC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved100</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved85</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_50ms_Group256_Reserved96</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoadCrvtDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoadCrvt_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoadSlopeDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoadSlope_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoughRoaddetectionDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RoughRoaddetection_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSCnfmSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSLFnChngSwA_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSPB1SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSPB2SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSPB3SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSSelLSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SWSSelRSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VehboardSetting_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a03148f4f31c9d200">
                          <SHORT-NAME>ICBVC_SecOC_SyncMsg</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOC_SyncMsg</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380caa00">
                          <SHORT-NAME>IMCU_PTCANFD_20ms_Container01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IMCU_PTCANFD_20ms_Container01_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IMCU_PTCANFD_20ms_Container01</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380c8600">
                          <SHORT-NAME>IMCU_SFCANFD_10ms_Container08</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IMCU_SFCANFD_10ms_Container08_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IMCU_SFCANFD_10ms_Container08</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380e0700">
                          <SHORT-NAME>IPD_100ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_100ms_PDU03_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjExistPrblty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjId</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjLatRltvDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjLongtRltvDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjLongtRltvSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjSyncCtr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCDetObjTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38152700">
                          <SHORT-NAME>IPD_20ms_PDU43</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_PDU43_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCAccReqToqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ACCSysFltSts_SCS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FrtCarGoNotfr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group43_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38137900">
                          <SHORT-NAME>IPD_20ms_PDU64</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_PDU64_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU64</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAEnToqReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAEnToqReqVal_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSBrkFnMd_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSBrkFn_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSDrvrReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSParkngPrflReq_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSParkngTrgtDist_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSParkngVelMax_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APASCSReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_CRC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_RC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group64_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38183300">
                          <SHORT-NAME>IPD_20ms_PDU67</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_20ms_PDU67_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU67</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ADS_SpdAstSysTrgtSpdV_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ADS_SpdAstSysTrgtSpd_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_20ms_Group67_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f444c2100">
                          <SHORT-NAME>IPD_50ms_PDU49</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/IPD_50ms_PDU49_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/APAEnRunReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_50ms_Group49_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/KeepPwrRsnIPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SysPwrMdCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380d2800">
                          <SHORT-NAME>NmPDU_PTCANFD_CCU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_CCU_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380d1d00">
                          <SHORT-NAME>NmPDU_PTCANFD_ESS</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_ESS_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380dc200">
                          <SHORT-NAME>NmPDU_PTCANFD_IPD</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_IPD_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_NKI_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_NOI_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_NWI_PTCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38156c00">
                          <SHORT-NAME>NmPDU_PTCANFD_LVBM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_LVBM_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380ec900">
                          <SHORT-NAME>NmPDU_PTCANFD_MMCU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_MMCU_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38127a00">
                          <SHORT-NAME>NmPDU_PTCANFD_PEU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_PEU_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380ed400">
                          <SHORT-NAME>NmPDU_PTCANFD_PICM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_PICM_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380edf00">
                          <SHORT-NAME>NmPDU_PTCANFD_RZCU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_RZCU_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38126f00">
                          <SHORT-NAME>NmPDU_PTCANFD_SAC</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_SAC_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380d3300">
                          <SHORT-NAME>NmPDU_PTCANFD_ZXD</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/NmPDU_PTCANFD_ZXD_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380c4100">
                          <SHORT-NAME>PEU_10ms_PDU25</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PEU_10ms_PDU25_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PEU_10ms_PDU25</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotADampTrqCmdd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotAMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotASpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotASpdSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotASpdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotAToqAch</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotAToqAchV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBDampTrqCmdd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBSpdSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBSpdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBToqAch</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEUMotBToqAchV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25_Reserved147</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PEU_10ms_Group25_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ReAxleMaxAvlblWhlDrvTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ReAxleMaxAvlblWhlDrvTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ReAxleMaxAvlblWhlRgtnTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ReAxleMaxAvlblWhlRgtnTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3817e200">
                          <SHORT-NAME>PICM_100ms_PDU06</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICM_100ms_PDU06_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICM_100ms_PDU06</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EDUClntTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EDUClntTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTElecWtrPumpActuSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38145100">
                          <SHORT-NAME>PICU_10ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_PDU03_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrReqFrtAxleWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrReqFrtAxleWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrReqRrAxleWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrReqRrAxleWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FrtAxleActuWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FrtAxleActuWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group03_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PtHVCntarReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RrAxleActuWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RrAxleActuWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TotActuWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TotActuWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38144600">
                          <SHORT-NAME>PICU_10ms_PDU23</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_10ms_PDU23_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU23</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CrkshftNonTrRegdCmddToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnComFlrRducdPwrCmdd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnDclFuelCutOffAld</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnDclFuelCutOffReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnDclFuelCutOffSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnFuelCutA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnFuelRcvrySpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnHybVehStaOvrd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnIdleCtrlA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnIdleCtrlSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnReqdStTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnStCtrlA_PICU_10ms_Group23_PICU_10ms_Group23_PICU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnSynRdy</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EnSysDsbld</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HybEnSpdReqF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HybEnStSpOvrd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group23_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group23_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_10ms_Group23_Reserved18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PtACCA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RVSEnRunning</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38179000">
                          <SHORT-NAME>PICU_20ms_PDU11</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/PICU_20ms_PDU11_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_20ms_PDU11</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CstRgtnBrkLgtReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CstRgtnBrkLgtReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/HybAPAAvlbl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/MaxAvlblTotWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/MaxAvlblTotWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/MinAvlblTotWhlToq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/MinAvlblTotWhlToqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PICU_20ms_Group11_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RdundtHybCmddEnToqImmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RdundtHybCmddEnToqPrdtd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RdundtHybCmddEnToqRespTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38112900">
                          <SHORT-NAME>RZCU_1000ms_PDU67</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_1000ms_PDU67_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_1000ms_PDU67</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IMU_SN_IMU_SN_IMU_SN</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38147300">
                          <SHORT-NAME>RZCU_100ms_PDU10</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_100ms_PDU10_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU10</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EleccLckCtrlResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FlbStrgFnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/FlbStrgFnStsResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/IMU_Signal_status</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OfbdChrgrNgtvSktTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OfbdChrgrNgtvSktTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrSktElecLckSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrSktElecLckStaV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrSktPstvSnsrTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnBdChrgrSktPstvSnsrTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/OnbdChrgrSktEleccLckEnable</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_100ms_Group10_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VCUCtrlS2Req</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38142500">
                          <SHORT-NAME>RZCU_10ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU01_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutoChrgngMngmnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTAccelActuPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTAccelActuPosV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTAccelEfctvPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTBrkPdlDscrtInptSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTBrkPdlDscrtInptStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTCrkAbotd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTHVDCDCMdReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTHVEmgcPwrOffReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTMainRelayDrvReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTStCmdOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ElecMotEmgcShutDwn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RVSEPTRdy</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group01_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3816e900">
                          <SHORT-NAME>RZCU_10ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU02_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTSecyAxleInptShaftSpdV_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTSecyAxleInptShaftSpd_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrInptShaftSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrInptShaftSpdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrInptShaftSpdV_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrInptShaftSpd_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f4438e300">
                          <SHORT-NAME>RZCU_10ms_PDU22</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU22_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU22</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotMaxAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotMaxAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotMinAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotMinAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTTrOtptShaftTotToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group22_CRC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group22_RC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group22_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group22_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VMCTarReWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VMCTarReWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VMCTarWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VMCTarWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN20000011a02779c9f443ef700">
                          <SHORT-NAME>RZCU_10ms_PDU23</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU23_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU23</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AIPilotSysSaBrInh_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AIPilotSysSaBrSts_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AccelOvrd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutodDrvngToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PtACCToqReqResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PtAPAToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group23_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380c9e00">
                          <SHORT-NAME>RZCU_10ms_PDU24</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU24_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU24</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTAPARevrDrgReqResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/PtAPASts_RZCU_10ms_Group24_RZCU_10ms_Group24_RZCU_10ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group24_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VCUAPAFltRsn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VCUAPAUnderCtrlA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38188700">
                          <SHORT-NAME>RZCU_10ms_PDU90</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_10ms_PDU90_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU90</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved135</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved143</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved151</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved159</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved83</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved87</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_Group90_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VCU_ISAOvSpdOvRd_RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3816f400">
                          <SHORT-NAME>RZCU_20ms_PDU06</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_20ms_PDU06_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU06</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTRdy</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EPTRdyV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_Group06_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEngdSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEngdStaV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEstdGear</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEstdGearV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrShftLvrPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrShftLvrPosV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380cb600">
                          <SHORT-NAME>RZCU_20ms_PDU07</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU07</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380e9a00">
                          <SHORT-NAME>RZCU_50ms_PDU25</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/RZCU_50ms_PDU25_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU25</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCUIgnDiagSts_RZCUIgnDiagSts_RZCUIgnDiagSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCUIgnSts_RZCUIgnSts_RZCUIgnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b380dfb00">
                          <SHORT-NAME>SDM_20ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/SDM_20ms_PDU03_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SDM_20ms_Group03_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VSELatAccV_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VSELatAcc_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VSELongtAccV_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VSELongtAcc_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VehDynYawRateV_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/VehDynYawRate_SDM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3814ce00">
                          <SHORT-NAME>TCM_020ms_PDU181</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_020ms_PDU18_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_020ms_PDU18</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/CluActTorq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SCUAPAUnderCtrlA_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/SCUDrvrIntrvnA_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18_CRC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18_RC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18_Reserve01_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18_Reserve02_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_020ms_PDU18_Reserve03_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrAPACanclReq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b38143000">
                          <SHORT-NAME>TCM_025ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU02_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/AutocTrCmddGear_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrShftCtrlReqDndIO</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/DrvrShftCtrlTrgtGear_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_Group02_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_Group02_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrCrpMdA_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEPBAppReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEngdStaV_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEngdSta_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEstdGearV_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrEstdGear_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrIntnlSwPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrIntnlSwPosV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrPrkPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrPrkSysF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrShftLvrPosV_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrShftLvrPos_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrShftPtrnASts_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrTapUpTapDwnMdSts_TCM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrTrgtShftLvrPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e3627a00">
                          <SHORT-NAME>TCM_025ms_PDU05</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU05_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU05</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU05_CRC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU05_RC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU05_Reserve01_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrGearV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrGear_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrImmdCrkshftToqReqVal_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrImmdCrkshftToqRespTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrPrdtdCrkshftToqIntrvnTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrPrdtdCrkshftToqReqV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e3624200">
                          <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TCM_025ms_PDU20_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU20</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_CRC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_RC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_Reserve01_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_Reserve02_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_Reserve03_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_Reserve04_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/TrACCToqReqResp_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b380959xN200000119f4464397e3305a00">
                          <SHORT-NAME>TC_IMCU_50ms_PDU28</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_PTCANFD/TC_IMCU_50ms_PDU28_IPD_PTCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TC_IMCU_50ms_PDU28</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EDUOilTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/EDUOilTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                      </PDU-TRIGGERINGS>
                    </CAN-PHYSICAL-CHANNEL>
                  </PHYSICAL-CHANNELS>
                  <CAN-FD-BAUDRATE>2000000</CAN-FD-BAUDRATE>
                </CAN-CLUSTER-CONDITIONAL>
              </CAN-CLUSTER-VARIANTS>
            </CAN-CLUSTER>
            <CAN-CLUSTER UUID="Oa505a3f19f25843c4b3f8ad4XOa505a3f19f25843c4b3f8ad300">
              <SHORT-NAME>SFCANFD</SHORT-NAME>
              <CAN-CLUSTER-VARIANTS>
                <CAN-CLUSTER-CONDITIONAL>
                  <BAUDRATE>500000</BAUDRATE>
                  <PHYSICAL-CHANNELS>
                    <CAN-PHYSICAL-CHANNEL UUID="Oa505a3f19f25843c4b3f8ae7XOa505a3f19f25843c4b3f8ae600">
                      <SHORT-NAME>SFCANFD</SHORT-NAME>
                      <COMM-CONNECTORS>
                        <COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                          <COMMUNICATION-CONNECTOR-REF DEST="CAN-COMMUNICATION-CONNECTOR">/Topology/HardwareComponents/IPD/IPD_SFCANFD</COMMUNICATION-CONNECTOR-REF>
                        </COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                      </COMM-CONNECTORS>
                      <FRAME-TRIGGERINGS>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce2d000">
                          <SHORT-NAME>IBS_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IBS_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_IBS</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1272</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f4464397e335a100">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP27</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ICBAD_BKPCANFD_100ms_FrP27_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP27</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ICBAD_100ms_PDU27</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>348</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce2fe00">
                          <SHORT-NAME>IPD_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_IPD</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1202</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cea0200">
                          <SHORT-NAME>LHZCU_LHBKBCANFDF_400ms_FrP18</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_LHBKBCANFDF_400ms_FrP18_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFDF_400ms_FrP18</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_PDU18</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1150</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce6d400">
                          <SHORT-NAME>PEU_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PEU_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/PEU_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_PEU</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1170</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce32c00">
                          <SHORT-NAME>PICM_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PICM_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/PICM_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_PICM</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1196</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce47400">
                          <SHORT-NAME>RZCU_ERCANFD_100ms_FrP49</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RZCU_ERCANFD_100ms_FrP49_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_ERCANFD_100ms_FrP49</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RZCU_100ms_PDU49</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>842</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce44e00">
                          <SHORT-NAME>RZCU_ERCANFD_10ms_FrP41</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RZCU_ERCANFD_10ms_FrP41_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_ERCANFD_10ms_FrP41</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RZCU_10ms_PDU41</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>94</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce35a00">
                          <SHORT-NAME>RZCU_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RZCU_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_RZCU</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1267</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce5a400">
                          <SHORT-NAME>SDM_CHCANFD_100ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_CHCANFD_100ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/SDM_CHCANFD_100ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_100ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1013</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cf11200">
                          <SHORT-NAME>SDM_CHCANFD_20ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_CHCANFD_20ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/SDM_CHCANFD_20ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>355</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce5ca00">
                          <SHORT-NAME>SDM_CHCANFD_20ms_FrP02</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_CHCANFD_20ms_FrP02_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/SDM_CHCANFD_20ms_FrP02</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_PDU02</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>391</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce38800">
                          <SHORT-NAME>SDM_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/SDM_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_SDM</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1251</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce96a00">
                          <SHORT-NAME>TDM_SFCANFD_200ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_SFCANFD_200ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/TDM_SFCANFD_200ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1103</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ce8ca00">
                          <SHORT-NAME>TDM_SFCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_SFCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/TDM_SFCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/NmPDU_SFCANFD_TDM</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1271</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                      </FRAME-TRIGGERINGS>
                      <I-SIGNAL-TRIGGERINGS>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98e400">
                          <SHORT-NAME>AirbagDpl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagDpl_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDpl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9ae600">
                          <SHORT-NAME>AirbagDplForeCall</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagDplForeCall_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplForeCall</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98f300">
                          <SHORT-NAME>AirbagDplInvsn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagDplInvsn_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9af900">
                          <SHORT-NAME>AirbagDplInvsneForeCall</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagDplInvsneForeCall_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsneForeCall</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c990200">
                          <SHORT-NAME>AirbagSysFlt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagSysFlt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFlt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b0c00">
                          <SHORT-NAME>AirbagSysFltForeCall</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagSysFltForeCall_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltForeCall</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c991100">
                          <SHORT-NAME>AirbagSysFltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/AirbagSysFltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccbcf00">
                          <SHORT-NAME>BrkLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/BrkLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtF_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccbe100">
                          <SHORT-NAME>BrkLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/BrkLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtOn_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c5700">
                          <SHORT-NAME>ChrgPwrReq_kW_ChrgPwrReq_kW_ChrgPwrReq_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ChrgPwrReq_kW_ChrgPwrReq_kW_ChrgPwrReq_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChrgPwrReq_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8cfc00">
                          <SHORT-NAME>ChrgReq_flg_ChrgReq_flg_ChrgReq_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ChrgReq_flg_ChrgReq_flg_ChrgReq_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChrgReq_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c3900">
                          <SHORT-NAME>DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0</SHORT-NAME>
