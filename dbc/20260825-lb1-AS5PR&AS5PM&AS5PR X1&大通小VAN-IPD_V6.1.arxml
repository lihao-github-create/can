                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_NOSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378dc6XOa505a3f19f25843c4b378dc500">
              <SHORT-NAME>IRHRDA_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_NOStoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_NOStoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_NOStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378eb9XOa505a3f19f25843c4b378eb800">
              <SHORT-NAME>IRHRDA_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_PBSMtoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_PBSMtoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_PBSMtoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378f76XOa505a3f19f25843c4b378f7500">
              <SHORT-NAME>IRHRDA_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_RMSSta_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_RMSSta_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_RMSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378de1XOa505a3f19f25843c4b378de000">
              <SHORT-NAME>IRHRDA_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_RMStoNOS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_RMStoNOS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_RMStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379084XOa505a3f19f25843c4b37908300">
              <SHORT-NAME>IRHRDA_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_RSStoNOS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_RSStoNOS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_RSStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378dfcXOa505a3f19f25843c4b378dfb00">
              <SHORT-NAME>IRHRDA_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA_NM_RSStoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NM_RSStoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NM_RSStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379069XOa505a3f19f25843c4b37906800">
              <SHORT-NAME>IRHRDA_NOI_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA BKPCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NOI_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NOI_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378e9eXOa505a3f19f25843c4b378e9d00">
              <SHORT-NAME>IRHRDA_NWI_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHRDA BKPCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHRDA_NWI_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHRDA_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_NWI_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e83aaXOa505a3f19f25843c4b2e83a900">
              <SHORT-NAME>IRHSwPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHSw Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHSwPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHSwPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHSwPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ba69XOa505a3f19f25843c4b36ba6800">
              <SHORT-NAME>IRHZCUAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU BKBCANFD Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36bb80XOa505a3f19f25843c4b36bb7f00">
              <SHORT-NAME>IRHZCUIgnDiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU Ignition Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:,有无服务标签:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:VS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUIgnDiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUIgnDiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUIgnDiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36bb9fXOa505a3f19f25843c4b36bb9e00">
              <SHORT-NAME>IRHZCUIgnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU Ignition Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:,有无服务标签:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:VS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUIgnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUIgnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUIgnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fea5XOa505a3f19f25843c4b37fea400">
              <SHORT-NAME>IRHZCU_100ms_Group10_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_100ms_Group10_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fec1XOa505a3f19f25843c4b37fec000">
              <SHORT-NAME>IRHZCU_100ms_Group10_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_100ms_Group10_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3057a1XOa505a3f19f25843c4b3057a000">
              <SHORT-NAME>IRHZCU_100ms_Group10_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_Reserved1</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3057b9XOa505a3f19f25843c4b3057b800">
              <SHORT-NAME>IRHZCU_100ms_Group10_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_Reserved2</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3057d0XOa505a3f19f25843c4b3057cf00">
              <SHORT-NAME>IRHZCU_100ms_Group10_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_Reserved3</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3057e7XOa505a3f19f25843c4b3057e600">
              <SHORT-NAME>IRHZCU_100ms_Group10_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_100ms_Group10_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_100ms_Group10_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368e00XOa505a3f19f25843c4b368dff00">
              <SHORT-NAME>IRHZCU_50ms_Group01_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_50ms_Group01_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368e1fXOa505a3f19f25843c4b368e1e00">
              <SHORT-NAME>IRHZCU_50ms_Group01_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_50ms_Group01_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ec93XOa505a3f19f25843c4b30ec9200">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ecaaXOa505a3f19f25843c4b30eca900">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved2</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ecc1XOa505a3f19f25843c4b30ecc000">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved3</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ecd8XOa505a3f19f25843c4b30ecd700">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ecefXOa505a3f19f25843c4b30ecee00">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved5</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ed06XOa505a3f19f25843c4b30ed0500">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved6</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved6</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30ed1dXOa505a3f19f25843c4b30ed1c00">
              <SHORT-NAME>IRHZCU_50ms_Group01_Reserved7</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group01_Reserved7</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368e5dXOa505a3f19f25843c4b368e5c00">
              <SHORT-NAME>IRHZCU_50ms_Group27_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_50ms_Group27_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368e7cXOa505a3f19f25843c4b368e7b00">
              <SHORT-NAME>IRHZCU_50ms_Group27_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU_50ms_Group27_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30021aXOa505a3f19f25843c4b30021900">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved1</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300231XOa505a3f19f25843c4b30023000">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved2</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300248XOa505a3f19f25843c4b30024700">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved3</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30025fXOa505a3f19f25843c4b30025e00">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved4</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300276XOa505a3f19f25843c4b30027500">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved5</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30028dXOa505a3f19f25843c4b30028c00">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved6</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved6</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3002a4XOa505a3f19f25843c4b3002a300">
              <SHORT-NAME>IRHZCU_50ms_Group27_Reserved7</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCU_50ms_Group27_Reserved7</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCU_50ms_Group27_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5d78XOa505a3f19f25843c4b2e5d7700">
              <SHORT-NAME>IRHZCUeFs1DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse1 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs1DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs1DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs1DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5d97XOa505a3f19f25843c4b2e5d9600">
              <SHORT-NAME>IRHZCUeFs1Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse1 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs1Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs1Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs1Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5dd5XOa505a3f19f25843c4b2e5dd400">
              <SHORT-NAME>IRHZCUeFs2DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse2 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs2DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs2DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs2DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5df4XOa505a3f19f25843c4b2e5df300">
              <SHORT-NAME>IRHZCUeFs2Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse2 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs2Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs2Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5e32XOa505a3f19f25843c4b2e5e3100">
              <SHORT-NAME>IRHZCUeFs3DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse3 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs3DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs3DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5e51XOa505a3f19f25843c4b2e5e5000">
              <SHORT-NAME>IRHZCUeFs3Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eFuse3 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeFs3Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeFs3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs3Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e60bdXOa505a3f19f25843c4b2e60bc00">
              <SHORT-NAME>IRHZCUeSw10DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch10 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw10DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw10DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw10DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e60dcXOa505a3f19f25843c4b2e60db00">
              <SHORT-NAME>IRHZCUeSw10Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch10 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw10Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw10Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw10Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e61d4XOa505a3f19f25843c4b2e61d300">
              <SHORT-NAME>IRHZCUeSw14DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch14 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw14DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw14DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw14DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e61f3XOa505a3f19f25843c4b2e61f200">
              <SHORT-NAME>IRHZCUeSw14Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch14 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw14Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw14Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw14Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e649dXOa505a3f19f25843c4b2e649c00">
              <SHORT-NAME>IRHZCUeSw31DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch31 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw31DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw31DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw31DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36591fXOa505a3f19f25843c4b36591e00">
              <SHORT-NAME>IRHZCUeSw31Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch31 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw31Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw31Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw31Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373d60XOa505a3f19f25843c4b373d5f00">
              <SHORT-NAME>IRHZCUeSw33DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch33 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw33DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw33DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw33DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373d7fXOa505a3f19f25843c4b373d7e00">
              <SHORT-NAME>IRHZCUeSw33Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch33 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw33Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw33Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw33Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317c31XOa505a3f19f25843c4b317c3000">
              <SHORT-NAME>IRHZCUeSw34DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch34 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw34DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw34DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw34DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317c12XOa505a3f19f25843c4b317c1100">
              <SHORT-NAME>IRHZCUeSw34Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch34 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw34Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw34Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw34Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6519XOa505a3f19f25843c4b2e651800">
              <SHORT-NAME>IRHZCUeSw37DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch37 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw37DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw37DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw37DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6538XOa505a3f19f25843c4b2e653700">
              <SHORT-NAME>IRHZCUeSw37Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch37 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw37Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw37Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw37Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5fa6XOa505a3f19f25843c4b2e5fa500">
              <SHORT-NAME>IRHZCUeSw3DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch3 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw3DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw3DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e5fc5XOa505a3f19f25843c4b2e5fc400">
              <SHORT-NAME>IRHZCUeSw3Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch3 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw3Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw3Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373e58XOa505a3f19f25843c4b373e5700">
              <SHORT-NAME>IRHZCUeSw41DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch41 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw41DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw41DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw41DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373e77XOa505a3f19f25843c4b373e7600">
              <SHORT-NAME>IRHZCUeSw41Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch41 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw41Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw41Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw41Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373d9eXOa505a3f19f25843c4b373d9d00">
              <SHORT-NAME>IRHZCUeSw42DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch42 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw42DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw42DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw42DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373dbdXOa505a3f19f25843c4b373dbc00">
              <SHORT-NAME>IRHZCUeSw42Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch42 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw42Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw42Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw42Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373ddcXOa505a3f19f25843c4b373ddb00">
              <SHORT-NAME>IRHZCUeSw43DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch43 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw43DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw43DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw43DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373dfbXOa505a3f19f25843c4b373dfa00">
              <SHORT-NAME>IRHZCUeSw43Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch43 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw43Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw43Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw43Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6060XOa505a3f19f25843c4b2e605f00">
              <SHORT-NAME>IRHZCUeSw9DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch9 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw9DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw9DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw9DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e607fXOa505a3f19f25843c4b2e607e00">
              <SHORT-NAME>IRHZCUeSw9Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RHZCU eSwitch9 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group27
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHZCUeSw9Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHZCUeSw9Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw9Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37df4fXOa505a3f19f25843c4b37df4e00">
              <SHORT-NAME>IRHandAntFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Hand Antenna Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RHandAntFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RHandAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHandAntFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37bfcfXOa505a3f19f25843c4b37bfce00">
              <SHORT-NAME>IRLDircnLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Left_Rear_Direction_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:左后转向灯控制
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDircnLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b8b4XOa505a3f19f25843c4b34b8b300">
              <SHORT-NAME>IRLDircnLghtFltsts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left_Direction_Light_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后左转向灯故障状态
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDircnLghtFltsts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtFltsts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b15fXOa505a3f19f25843c4b37b15e00">
              <SHORT-NAME>IRLDircnLghtFltsts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Left_Rear_Direction_Light_Fault_Status_HardWired</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:左后转向灯故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDircnLghtFltsts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtFltsts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtFltsts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b8cfXOa505a3f19f25843c4b34b8ce00">
              <SHORT-NAME>IRLDircnLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left_Direction_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后左转向灯点亮状态
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDircnLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b17aXOa505a3f19f25843c4b37b17900">
              <SHORT-NAME>IRLDircnLghtSts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Left Rear Direction Light Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:左后转向灯状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDircnLghtSts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDircnLghtSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtSts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e345fXOa505a3f19f25843c4b2e345e00">
              <SHORT-NAME>IRLDoorLckSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Door Lock Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:左后门锁状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDoorLckSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDoorLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDoorLckSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e347eXOa505a3f19f25843c4b2e347d00">
              <SHORT-NAME>IRLDoorOpenSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Door Open Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group06
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:电动门信号，左后车门状态反馈功能
接收方描述:DoorRlseCinchDrvMdl_LH
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，电动窗，音响,SDM,IBS,AC,空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLDoorOpenSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDoorOpenSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324582XOa505a3f19f25843c4b32458100">
              <SHORT-NAME>IRLObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b75dXOa505a3f19f25843c4b34b75c00">
              <SHORT-NAME>IRLRdrEmgcLineChngWrnng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Radar Emergency Line Change Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHRDA_50ms_Group04
功能安全:
信息安全:
有无服务标签:
发送方描述:LEFT ELK flag
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLRdrEmgcLineChngWrnng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLRdrEmgcLineChngWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLRdrEmgcLineChngWrnng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e9c4XOa505a3f19f25843c4b37e9c300">
              <SHORT-NAME>IRLSInitnFltPrst</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rain Light Sensor Initialization Fault Present</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSInitnFltPrst</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSInitnFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSInitnFltPrst</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32461dXOa505a3f19f25843c4b32461c00">
              <SHORT-NAME>IRLSObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Side Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e83c9XOa505a3f19f25843c4b2e83c800">
              <SHORT-NAME>IRLSSPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RLSS Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSSPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSSPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323dc2XOa505a3f19f25843c4b323dc100">
              <SHORT-NAME>IRLSUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Side USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37a1c4XOa505a3f19f25843c4b37a1c300">
              <SHORT-NAME>IRLSideLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Left_Rear_Side_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:左后位置灯控制
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSideLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSideLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSideLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324715XOa505a3f19f25843c4b32471400">
              <SHORT-NAME>IRLSideObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Side Obstacle Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSideObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSideObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346d2eXOa505a3f19f25843c4b346d2d00">
              <SHORT-NAME>IRLSuperLckSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left SuperLock Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:左后超级锁状态反馈
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLSuperLckSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSuperLckSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3176ddXOa505a3f19f25843c4b3176dc00">
              <SHORT-NAME>IRLTirePrs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Tire Pressure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:左后轮胎压
接收方描述:IAM,IPD,RZCU,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLTirePrs</SHORT-LABEL>
                  <VALUE>0x37</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTirePrs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317987XOa505a3f19f25843c4b31798600">
              <SHORT-NAME>IRLTirePrsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Left_Tire_Pressure_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:左后轮胎压有效性
接收方描述:IAM,IPD,RZCU,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLTirePrsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTirePrsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f498f2acb40536XNa505a3f19f498f2acb4052500">
              <SHORT-NAME>IRLTireSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Left_Tire_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:胎压状态
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLTireSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2043XOa505a3f19f25843c4b2e204200">
              <SHORT-NAME>IRLTireTem</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Tire Temperature</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:左后轮胎温度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:胎压</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLTireTem</SHORT-LABEL>
                  <VALUE>0x2D</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireTem</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2081XOa505a3f19f25843c4b2e208000">
              <SHORT-NAME>IRLTireTemV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left Tire Temperature Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:左后轮胎温度有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:胎压</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLTireTemV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireTemV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323ef8XOa505a3f19f25843c4b323ef700">
              <SHORT-NAME>IRLUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Left USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RLUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323d08XOa505a3f19f25843c4b323d0700">
              <SHORT-NAME>IRMLUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Middle Left USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RMLUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMLUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMLUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323ed9XOa505a3f19f25843c4b323ed800">
              <SHORT-NAME>IRMRUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Middle Right USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RMRUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMRUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3595XOa505a3f19f25843c4b2e359400">
              <SHORT-NAME>IRMainBeamLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Main_beam_Light _Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:右侧远光灯控制
接收方描述:右侧远光灯控制
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RMainBeamLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMainBeamLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMainBeamLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e65b4XOa505a3f19f25843c4b2e65b300">
              <SHORT-NAME>IRMainBeamLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Main_beam_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右侧远光灯状态
接收方描述:右侧远光灯状态
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RMainBeamLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RMainBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMainBeamLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366619XOa505a3f19f25843c4b36661800">
              <SHORT-NAME>IRNonDrvnWhlRotlDircn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Direction</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:右前轮转向,右前轮旋转方向
接收方描述:ZXDAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDircn</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366638XOa505a3f19f25843c4b36663700">
              <SHORT-NAME>IRNonDrvnWhlRotlDircnSdslSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Direction Standstill Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL A,ASILB
信息安全:
有无服务标签:
发送方描述:有前轮standstill状态,右前轮standstill状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDircnSdslSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDircnSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365c50XOa505a3f19f25843c4b365c4f00">
              <SHORT-NAME>IRNonDrvnWhlRotlDistPC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Distance Pulse Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASIL
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDistPC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistPC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistPC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365c70XOa505a3f19f25843c4b365c6f00">
              <SHORT-NAME>IRNonDrvnWhlRotlDistT</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Distance Timestamp</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDistT</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistT</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistT</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365c90XOa505a3f19f25843c4b365c8f00">
              <SHORT-NAME>IRNonDrvnWhlRotlDistTRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Distance Timestamp Rollover Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDistTRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistTRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365cb0XOa505a3f19f25843c4b365caf00">
              <SHORT-NAME>IRNonDrvnWhlRotlDistV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Distance Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlDistV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlDistV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365cd0XOa505a3f19f25843c4b365ccf00">
              <SHORT-NAME>IRNonDrvnWhlRotlRstOcd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Reset Occurred</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlRstOcd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlRstOcd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365cf0XOa505a3f19f25843c4b365cef00">
              <SHORT-NAME>IRNonDrvnWhlRotlSeqNum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Non Driven Wheel Rotational Sequence Number</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group02
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:轮速脉冲,右前轮齿数脉冲
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RNonDrvnWhlRotlSeqNum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RNonDrvnWhlRotlSeqNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e65f2XOa505a3f19f25843c4b2e65f100">
              <SHORT-NAME>IROtsdMirFoldSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Outside_Mirror_Fold_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:发送右后视镜展开/折叠/运行中/故障状态反馈
接收方描述:接收右后视镜展开/折叠/运行中/故障状态反馈
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:后视镜</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ROtsdMirFoldSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirFoldSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ROtsdMirFoldSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371f90XOa505a3f19f25843c4b371f8f00">
              <SHORT-NAME>IROtsdMirHoztSwActReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Outside_Mirror_Horizontal_Switch_Action_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:发送右后视镜开关水平调节请求
接收方描述:接收右后视镜开关水平调节请求
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:后视镜</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ROtsdMirHoztSwActReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirHoztSwActReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ROtsdMirHoztSwActReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371fceXOa505a3f19f25843c4b371fcd00">
              <SHORT-NAME>IROtsdMirVertSwActReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Outside_Mirror_Vertical_Switch_Action_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:发送右后视镜开关垂直调节请求
接收方描述:接收右后视镜开关垂直调节请求
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:后视镜</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ROtsdMirVertSwActReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ROtsdMirVertSwActReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ROtsdMirVertSwActReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31aed5XOa505a3f19f25843c4b31aed400">
              <SHORT-NAME>IRPShockDistL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The First Shock Feature Along The Rolling Path L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RPShockDistL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RPShockDistL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RPShockDistL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31ae1bXOa505a3f19f25843c4b31ae1a00">
              <SHORT-NAME>IRPShockDistR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The First Shock Feature Along The Rolling Path R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RPShockDistR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RPShockDistR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RPShockDistR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eeaabXOa505a3f19f25843c4b2eeaaa00">
              <SHORT-NAME>IRRCTAWrnng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Cross Traffic Alert Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RHRDA_50ms_Group04
功能安全:
信息安全:
有无服务标签:null
发送方描述:右RCTA报警信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRCTAWrnng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRCTAWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRCTAWrnng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37bfeaXOa505a3f19f25843c4b37bfe900">
              <SHORT-NAME>IRRDircnLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Rear_Direction_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:右后转向灯控制
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDircnLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b8eaXOa505a3f19f25843c4b34b8e900">
              <SHORT-NAME>IRRDircnLghtFltsts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Right_Direction_Light_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后右转向灯故障状态
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDircnLghtFltsts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtFltsts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b195XOa505a3f19f25843c4b37b19400">
              <SHORT-NAME>IRRDircnLghtFltsts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Rear_Direction_Light_Fault_Status_HardWired</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:右后转向灯故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDircnLghtFltsts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtFltsts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtFltsts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b905XOa505a3f19f25843c4b34b90400">
              <SHORT-NAME>IRRDircnLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Right_Direction_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后右转向灯点亮状态
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDircnLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b1b0XOa505a3f19f25843c4b37b1af00">
              <SHORT-NAME>IRRDircnLghtSts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Rear Direction Light Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:右后转向灯状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDircnLghtSts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDircnLghtSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtSts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368e3eXOa505a3f19f25843c4b368e3d00">
              <SHORT-NAME>IRRDoorOpenSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Door Open Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHZCU_50ms_Group01
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:电动门信号，右后车门状态反馈功能
接收方描述:DoorRlseCinchDrvMdl_RH
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，电动窗，音响,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRDoorOpenSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRDoorOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDoorOpenSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324354XOa505a3f19f25843c4b32435300">
              <SHORT-NAME>IRRObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b777XOa505a3f19f25843c4b34b77600">
              <SHORT-NAME>IRRRdrEmgcLineChngWrnng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Rear Radar Emergency Line Change Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHRDA_50ms_Group04
功能安全:
信息安全:
有无服务标签:
发送方描述:RIGHT ELK flag
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRRdrEmgcLineChngWrnng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRRdrEmgcLineChngWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRRdrEmgcLineChngWrnng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323cabXOa505a3f19f25843c4b323caa00">
              <SHORT-NAME>IRRSObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Side Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRSObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324699XOa505a3f19f25843c4b32469800">
              <SHORT-NAME>IRRSUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Side USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRSUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37a1dfXOa505a3f19f25843c4b37a1de00">
              <SHORT-NAME>IRRSideLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right_Rear_Side_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:右后位置灯控制
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRSideLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSideLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSideLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324145XOa505a3f19f25843c4b32414400">
              <SHORT-NAME>IRRSideObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Side Obstacle Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRSideObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSideObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSideObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34787cXOa505a3f19f25843c4b34787b00">
              <SHORT-NAME>IRRSuperLckSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right SuperLock Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:右后超级锁状态反馈
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRSuperLckSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRSuperLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSuperLckSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317b1aXOa505a3f19f25843c4b317b1900">
              <SHORT-NAME>IRRTirePrs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Tire Pressure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后轮胎压
接收方描述:IAM,IPD,RZCU,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRTirePrs</SHORT-LABEL>
                  <VALUE>0x37</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTirePrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTirePrs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3179a6XOa505a3f19f25843c4b3179a500">
              <SHORT-NAME>IRRTirePrsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Right_Tire_Pressure_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后轮胎压有效性
接收方描述:IAM,IPD,RZCU,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRTirePrsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTirePrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTirePrsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f498f2acb409a4XNa505a3f19f498f2acb4099300">
              <SHORT-NAME>IRRTireSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Right_Tire_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:胎压状态
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRTireSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1fe6XOa505a3f19f25843c4b2e1fe500">
              <SHORT-NAME>IRRTireTem</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Tire Temperature</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后轮胎温度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:胎压</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRTireTem</SHORT-LABEL>
                  <VALUE>0x2D</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireTem</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2062XOa505a3f19f25843c4b2e206100">
              <SHORT-NAME>IRRTireTemV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Tire Temperature Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后轮胎温度有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:胎压</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRTireTemV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRTireTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireTemV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32442dXOa505a3f19f25843c4b32442c00">
              <SHORT-NAME>IRRUSSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right USS Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRUSSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRUSSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRUSSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6630XOa505a3f19f25843c4b2e662f00">
              <SHORT-NAME>IRRWinIninSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window Initialized status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:新增RHZCU,   发送RR窗初始化状态信号
接收方描述:ZXD/ZXD 接收
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinIninSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinIninSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinIninSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e664fXOa505a3f19f25843c4b2e664e00">
              <SHORT-NAME>IRRWinLclSwtFlt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window Local Switch Fault</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后驾开关故障状态反馈
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinLclSwtFlt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinLclSwtFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinLclSwtFlt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e666eXOa505a3f19f25843c4b2e666d00">
              <SHORT-NAME>IRRWinLclSwtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window Local Switch Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后驾开关控制右前电动窗请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinLclSwtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinLclSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinLclSwtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e668dXOa505a3f19f25843c4b2e668c00">
              <SHORT-NAME>IRRWinMotFlt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window Motor Fault</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后摇窗机故障反馈:
all bits=0=Normal
bit0=1=Primary Thermal protection;
bit1=1=Secondary Thermal protection;
bit2=1=Hall Sensor error;
bit3=1= Over voltage
bit4=1= Under voltage
bit5=1= Motor short to ground
bit6=1= Motor short to PWR,
bit7=1=Motor Open circuit
bit 8--15, reserved
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinMotFlt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinMotFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinMotFlt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e66acXOa505a3f19f25843c4b2e66ab00">
              <SHORT-NAME>IRRWinMotSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window Motor Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:右后驾电动窗运动状态反馈
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinMotSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinMotSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinMotSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e66cbXOa505a3f19f25843c4b2e66ca00">
              <SHORT-NAME>IRRWinShrtDwnSucd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Window short down successed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU 发送右后窗短降状态信号
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RRWinShrtDwnSucd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinShrtDwnSucd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRWinShrtDwnSucd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368739XOa505a3f19f25843c4b36873800">
              <SHORT-NAME>IRVSEPTRdy</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote_Vehicle_Start_Electric_Powertrain_Ready</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:远程电机启动状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSEPTRdy</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSEPTRdy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSEPTRdy</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e4a60XOa505a3f19f25843c4b2e4a5f00">
              <SHORT-NAME>IRVSEnRunning</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Vehicle Start Engine Running</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PICU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSEnRunning</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSEnRunning</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSEnRunning</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3417c2XOa505a3f19f25843c4b3417c100">
              <SHORT-NAME>IRVSPtCrkAbotd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:ECM_010ms_Group00
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSPtCrkAbotd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtCrkAbotd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtCrkAbotd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b374649XOa505a3f19f25843c4b37464800">
              <SHORT-NAME>IRVSPtCrkAbotdRsn</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSPtCrkAbotdRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtCrkAbotdRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtCrkAbotdRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3417d9XOa505a3f19f25843c4b3417d800">
              <SHORT-NAME>IRVSPtRunAbotd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:ECM_010ms_Group00
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSPtRunAbotd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtRunAbotd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtRunAbotd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3754a7XOa505a3f19f25843c4b3754a600">
              <SHORT-NAME>IRVSPtRunAbotdRsn</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RVSPtRunAbotdRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtRunAbotdRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtRunAbotdRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322e0bXOa505a3f19f25843c4b322e0a00">
              <SHORT-NAME>IRZCUIgnDiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU Ignition Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:IPD,SDM,TC,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:VS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUIgnDiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUIgnDiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUIgnDiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322e49XOa505a3f19f25843c4b322e4800">
              <SHORT-NAME>IRZCUIgnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU Ignition Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:CCU,IPD,ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:VS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUIgnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUIgnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUIgnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3685f8XOa505a3f19f25843c4b3685f700">
              <SHORT-NAME>IRZCU_100ms_Group10_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_100ms_Group10_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368617XOa505a3f19f25843c4b36861600">
              <SHORT-NAME>IRZCU_100ms_Group10_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_100ms_Group10_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b305583XOa505a3f19f25843c4b30558200">
              <SHORT-NAME>IRZCU_100ms_Group10_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_Reserved1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30559bXOa505a3f19f25843c4b30559a00">
              <SHORT-NAME>IRZCU_100ms_Group10_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_Reserved2</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3055b2XOa505a3f19f25843c4b3055b100">
              <SHORT-NAME>IRZCU_100ms_Group10_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_Reserved3</SHORT-LABEL>
                  <VALUE>0x7f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3055c9XOa505a3f19f25843c4b3055c800">
              <SHORT-NAME>IRZCU_100ms_Group10_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_Reserved4</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3055e0XOa505a3f19f25843c4b3055df00">
              <SHORT-NAME>IRZCU_100ms_Group10_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_100ms_Group10_Reserved5</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368758XOa505a3f19f25843c4b36875700">
              <SHORT-NAME>IRZCU_10ms_Group01_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group01_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group01_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368777XOa505a3f19f25843c4b36877600">
              <SHORT-NAME>IRZCU_10ms_Group01_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group01_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group01_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3005c9XOa505a3f19f25843c4b3005c800">
              <SHORT-NAME>IRZCU_10ms_Group01_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group01_Reserved1</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3005e0XOa505a3f19f25843c4b3005df00">
              <SHORT-NAME>IRZCU_10ms_Group01_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group01_Reserved2</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3005f7XOa505a3f19f25843c4b3005f600">
              <SHORT-NAME>IRZCU_10ms_Group01_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group01_Reserved3</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368198XOa505a3f19f25843c4b36819700">
              <SHORT-NAME>IRZCU_10ms_Group02_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group02_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group02_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3681b7XOa505a3f19f25843c4b3681b600">
              <SHORT-NAME>IRZCU_10ms_Group02_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group02_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group02_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30060eXOa505a3f19f25843c4b30060d00">
              <SHORT-NAME>IRZCU_10ms_Group02_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group02_Reserved1</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c3b0XOa505a3f19f25843c4b34c3af00">
              <SHORT-NAME>IRZCU_10ms_Group22_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group22_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group22_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c086XOa505a3f19f25843c4b34c08500">
              <SHORT-NAME>IRZCU_10ms_Group22_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group22_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group22_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b0e1XOa505a3f19f25843c4b33b0e000">
              <SHORT-NAME>IRZCU_10ms_Group22_Reserved47</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group22_Reserved47</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_Reserved47</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b0f9XOa505a3f19f25843c4b33b0f800">
              <SHORT-NAME>IRZCU_10ms_Group22_Reserved95</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group22_Reserved95</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_Reserved95</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368509XOa505a3f19f25843c4b36850800">
              <SHORT-NAME>IRZCU_10ms_Group23_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group23_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368528XOa505a3f19f25843c4b36852700">
              <SHORT-NAME>IRZCU_10ms_Group23_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group23_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44dd6aXN20000011a02779c9f44dd6400">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved1</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44ea44XN20000011a02779c9f44ea3e00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved10</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved10</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved10</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44ebb1XN20000011a02779c9f44ebab00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved11</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved11</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved11</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44ed1aXN20000011a02779c9f44ed1400">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved12</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved12</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved12</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44ee83XN20000011a02779c9f44ee7d00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved13</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved13</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved13</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44eff5XN20000011a02779c9f44efef00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved14</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved14</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved14</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44f162XN20000011a02779c9f44f15c00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved15</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved15</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44dee2XN20000011a02779c9f44dedc00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved2</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e04fXN20000011a02779c9f44e04900">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved3</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e1b8XN20000011a02779c9f44e1b200">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved4</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e321XN20000011a02779c9f44e31b00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved5</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e493XN20000011a02779c9f44e48d00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved6</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved6</SHORT-LABEL>
                  <VALUE>0x7f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e600XN20000011a02779c9f44e5fa00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved7</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved7</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e769XN20000011a02779c9f44e76300">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved8</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved8</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved8</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N20000011a02779c9f44e8d2XN20000011a02779c9f44e8cc00">
              <SHORT-NAME>IRZCU_10ms_Group23_Reserved9</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group23_Reserved9</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved9</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3685afXOa505a3f19f25843c4b3685ae00">
              <SHORT-NAME>IRZCU_10ms_Group24_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group24_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3685ceXOa505a3f19f25843c4b3685cd00">
              <SHORT-NAME>IRZCU_10ms_Group24_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_10ms_Group24_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300722XOa505a3f19f25843c4b30072100">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved1</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300739XOa505a3f19f25843c4b30073800">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved2</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300750XOa505a3f19f25843c4b30074f00">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved3</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300767XOa505a3f19f25843c4b30076600">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30077eXOa505a3f19f25843c4b30077d00">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved5</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300795XOa505a3f19f25843c4b30079400">
              <SHORT-NAME>IRZCU_10ms_Group24_Reserved6</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group24_Reserved6</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3583ccXOa505a3f19f25843c4b3583cb00">
              <SHORT-NAME>IRZCU_10ms_Group90_CRC</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358598XOa505a3f19f25843c4b35859700">
              <SHORT-NAME>IRZCU_10ms_Group90_RC</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3584e0XOa505a3f19f25843c4b3584df00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved103</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved103</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved103</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3584f7XOa505a3f19f25843c4b3584f600">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved111</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved111</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved111</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35850eXOa505a3f19f25843c4b35850d00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved119</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved119</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved119</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358525XOa505a3f19f25843c4b35852400">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved127</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved127</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved127</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35853cXOa505a3f19f25843c4b35853b00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved135</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved135</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved135</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved135</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358553XOa505a3f19f25843c4b35855200">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved143</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved143</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved143</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved143</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3585afXOa505a3f19f25843c4b3585ae00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved15</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved15</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35856aXOa505a3f19f25843c4b35856900">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved151</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved151</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved151</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved151</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358581XOa505a3f19f25843c4b35858000">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved159</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved159</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved159</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved159</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3583e3XOa505a3f19f25843c4b3583e200">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved23</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved23</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved23</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3583faXOa505a3f19f25843c4b3583f900">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved31</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved31</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved31</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358411XOa505a3f19f25843c4b35841000">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved39</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved39</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved39</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358428XOa505a3f19f25843c4b35842700">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved47</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved47</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved47</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35843fXOa505a3f19f25843c4b35843e00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved55</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved55</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved55</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358456XOa505a3f19f25843c4b35845500">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved63</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved63</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved63</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35846dXOa505a3f19f25843c4b35846c00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved71</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved71</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved71</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b358484XOa505a3f19f25843c4b35848300">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved79</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved79</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved79</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3584b2XOa505a3f19f25843c4b3584b100">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved83</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved83</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved83</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved83</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b35849bXOa505a3f19f25843c4b35849a00">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved87</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved87</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved87</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3584c9XOa505a3f19f25843c4b3584c800">
              <SHORT-NAME>IRZCU_10ms_Group90_Reserved95</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_10ms_Group90_Reserved95</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved95</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36883cXOa505a3f19f25843c4b36883b00">
              <SHORT-NAME>IRZCU_20ms_Group06_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_20ms_Group06_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36885bXOa505a3f19f25843c4b36885a00">
              <SHORT-NAME>IRZCU_20ms_Group06_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_20ms_Group06_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300625XOa505a3f19f25843c4b30062400">
              <SHORT-NAME>IRZCU_20ms_Group06_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_Reserved1</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30063cXOa505a3f19f25843c4b30063b00">
              <SHORT-NAME>IRZCU_20ms_Group06_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_Reserved2</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300653XOa505a3f19f25843c4b30065200">
              <SHORT-NAME>IRZCU_20ms_Group06_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_Reserved3</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b30066aXOa505a3f19f25843c4b30066900">
              <SHORT-NAME>IRZCU_20ms_Group06_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b300681XOa505a3f19f25843c4b30068000">
              <SHORT-NAME>IRZCU_20ms_Group06_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_20ms_Group06_Reserved5</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c3cbXOa505a3f19f25843c4b34c3ca00">
              <SHORT-NAME>IRZCU_50ms_Group37_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_50ms_Group37_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c3e6XOa505a3f19f25843c4b34c3e500">
              <SHORT-NAME>IRZCU_50ms_Group37_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU_50ms_Group37_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6dc9XOa505a3f19f25843c4b2f6dc800">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved15</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved15</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6de0XOa505a3f19f25843c4b2f6ddf00">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved23</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved23</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved23</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6df7XOa505a3f19f25843c4b2f6df600">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved31</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved31</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved31</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6e3cXOa505a3f19f25843c4b2f6e3b00">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved34</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved34</SHORT-LABEL>
                  <VALUE>0x1f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved34</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved34</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6e25XOa505a3f19f25843c4b2f6e2400">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved36</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved36</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved36</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved36</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6e0eXOa505a3f19f25843c4b2f6e0d00">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved38</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved38</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved38</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved38</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f6e53XOa505a3f19f25843c4b2f6e5200">
              <SHORT-NAME>IRZCU_50ms_Group37_Reserved63</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_50ms_Group37_Reserved63</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved63</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9283XOa505a3f19f25843c4b2e928200">
              <SHORT-NAME>IRZCU_BKBCANFDAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU BKBCANFD  Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_BKBCANFDAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_BKBCANFDAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_BKBCANFDAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3724c3XOa505a3f19f25843c4b3724c200">
              <SHORT-NAME>IRZCU_NKI_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU CHCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NKI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NKI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37238dXOa505a3f19f25843c4b37238c00">
              <SHORT-NAME>IRZCU_NKI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NKI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NKI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3723cbXOa505a3f19f25843c4b3723ca00">
              <SHORT-NAME>IRZCU_NKI_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU SFCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NKI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NKI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3736afXOa505a3f19f25843c4b3736ae00">
              <SHORT-NAME>IRZCU_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_BSMtoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_BSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3728daXOa505a3f19f25843c4b3728d900">
              <SHORT-NAME>IRZCU_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_BSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_BSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3727e7XOa505a3f19f25843c4b3727e600">
              <SHORT-NAME>IRZCU_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_BSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_BSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372c55XOa505a3f19f25843c4b372c5400">
              <SHORT-NAME>IRZCU_NM_NOSSta_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOSSta_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOSSta_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373427XOa505a3f19f25843c4b37342600">
              <SHORT-NAME>IRZCU_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372d63XOa505a3f19f25843c4b372d6200">
              <SHORT-NAME>IRZCU_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373442XOa505a3f19f25843c4b37344100">
              <SHORT-NAME>IRZCU_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOStoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373493XOa505a3f19f25843c4b37349200">
              <SHORT-NAME>IRZCU_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373478XOa505a3f19f25843c4b37347700">
              <SHORT-NAME>IRZCU_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_NOStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_NOStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37314aXOa505a3f19f25843c4b37314900">
              <SHORT-NAME>IRZCU_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_PBSMtoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_PBSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373accXOa505a3f19f25843c4b373acb00">
              <SHORT-NAME>IRZCU_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_PBSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_PBSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3739a3XOa505a3f19f25843c4b3739a200">
              <SHORT-NAME>IRZCU_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_PBSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_PBSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372802XOa505a3f19f25843c4b37280100">
              <SHORT-NAME>IRZCU_NM_RMSSta_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMSSta_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMSSta_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37281dXOa505a3f19f25843c4b37281c00">
              <SHORT-NAME>IRZCU_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3737f3XOa505a3f19f25843c4b3737f200">
              <SHORT-NAME>IRZCU_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373694XOa505a3f19f25843c4b37369300">
              <SHORT-NAME>IRZCU_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMStoNOS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3737a2XOa505a3f19f25843c4b3737a100">
              <SHORT-NAME>IRZCU_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3730f9XOa505a3f19f25843c4b3730f800">
              <SHORT-NAME>IRZCU_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RMStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RMStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37292bXOa505a3f19f25843c4b37292a00">
              <SHORT-NAME>IRZCU_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoNOS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372961XOa505a3f19f25843c4b37296000">
              <SHORT-NAME>IRZCU_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3729b2XOa505a3f19f25843c4b3729b100">
              <SHORT-NAME>IRZCU_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372db4XOa505a3f19f25843c4b372db300">
              <SHORT-NAME>IRZCU_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373679XOa505a3f19f25843c4b37367800">
              <SHORT-NAME>IRZCU_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3739d9XOa505a3f19f25843c4b3739d800">
              <SHORT-NAME>IRZCU_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NM_RSStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NM_RSStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372deaXOa505a3f19f25843c4b372de900">
              <SHORT-NAME>IRZCU_NOI_CHCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NOI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NOI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3734aeXOa505a3f19f25843c4b3734ad00">
              <SHORT-NAME>IRZCU_NOI_PTCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NOI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NOI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372853XOa505a3f19f25843c4b37285200">
              <SHORT-NAME>IRZCU_NOI_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NOI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NOI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372447XOa505a3f19f25843c4b37244600">
              <SHORT-NAME>IRZCU_NWI_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU CHCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NWI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NWI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3724a4XOa505a3f19f25843c4b3724a300">
              <SHORT-NAME>IRZCU_NWI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU Network Wakeup Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NWI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NWI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372409XOa505a3f19f25843c4b37240800">
              <SHORT-NAME>IRZCU_NWI_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU SFCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_NWI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_NWI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375838XOa505a3f19f25843c4b37583700">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37584fXOa505a3f19f25843c4b37584e00">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33afd9XOa505a3f19f25843c4b33afd800">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved1</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33aff0XOa505a3f19f25843c4b33afef00">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved2</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b007XOa505a3f19f25843c4b33b00600">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved3</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b01eXOa505a3f19f25843c4b33b01d00">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b035XOa505a3f19f25843c4b33b03400">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved5</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved5</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b33b04cXOa505a3f19f25843c4b33b04b00">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64_Reserved6</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved6</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317324XOa505a3f19f25843c4b31732300">
              <SHORT-NAME>IRZCUeFs1DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse1 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝诊断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs1DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs1DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs1DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3174b7XOa505a3f19f25843c4b3174b600">
              <SHORT-NAME>IRZCUeFs1Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse1 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZCU 播报的保险丝通断状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs1Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs1Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs1Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31745aXOa505a3f19f25843c4b31745900">
              <SHORT-NAME>IRZCUeFs2DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse2 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs2DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs2DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs2DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b316e82XOa505a3f19f25843c4b316e8100">
              <SHORT-NAME>IRZCUeFs2Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse2 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs2Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs2Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317305XOa505a3f19f25843c4b31730400">
              <SHORT-NAME>IRZCUeFs3DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse3 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs3DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs3DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3174d6XOa505a3f19f25843c4b3174d500">
              <SHORT-NAME>IRZCUeFs3Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eFuse3 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeFs3Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
