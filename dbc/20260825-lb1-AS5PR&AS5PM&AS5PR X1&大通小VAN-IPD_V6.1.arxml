                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group13/ICBAD_20ms_Group13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group13</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APACmdEPSSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACmdEPSSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APAF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APASCUReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APASCUReqStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APAShifterPosReqd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APAShifterPosReqdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/APATrgtEPSStrgWhlAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group13/ICBAD_20ms_Group13_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group15/ICBAD_20ms_Group15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group15</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ACCDclReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDclReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ACCOtptShaftTotToqReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ACCOtptShaftTotToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/AutodDrvngSysStsPT</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsPT</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group15/ICBAD_20ms_Group15_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group46</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group46/ICBAD_20ms_Group46</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group46</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBBrkJerkLvlReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBBrkJerkLvlReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBDclReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBDclReqToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBDclReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBHydBrkAstLvlReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBHydBrkAstLvlReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBPrflReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBPrflReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/AEBSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/ICBAD_20ms_Group46_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/ICBAD_20ms_Group46_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/ICBAD_20ms_Group46_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group46/ICBAD_20ms_Group46_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group48</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group48/ICBAD_20ms_Group48</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group48</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/ICBAD_20ms_Group48_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/LDWLKALVsulznReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKALVsulznReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/LDWLKARVsulznReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKARVsulznReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/LDWLKAVbnLvlReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAVbnLvlReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/LDWSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group48/LDWSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_ZONE_10ms_Group20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_ZONE_10ms_Group20</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/ICBAD_ZONE_10ms_Group20_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/LKAToqReqValMax</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAToqReqValMax</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_10ms_Group20/LKAToqReqValMin</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAToqReqValMin</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_ZONE_20ms_Group13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_ZONE_20ms_Group13</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ACCToqReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ACCToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/ICBAD_ZONE_20ms_Group13_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/LKASysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKASysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/LKASysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKASysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/TJAICASysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_ZONE_20ms_Group13/TJAICASysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group01/ICBVC_100ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ClstrDspdVehSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClstrDspdVehSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/DspMeasmtSys</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DspMeasmtSys</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/FLSeatHeatCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatHeatCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/FLSeatVentCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatVentCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/FRSeatHeatCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatHeatCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/FRSeatVentCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatVentCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved21</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved21</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved72</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved72</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved80</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved80</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved84</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved84</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/ICBVC_100ms_Group01_Reserved92</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved92</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/MdOfPwrMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MdOfPwrMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/PDCSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDCSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group01/PwrMdExtrCtrlAvlbl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdExtrCtrlAvlbl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group19</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group19/ICBVC_100ms_Group19</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group19</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/AuxBatUnAssembled</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AuxBatUnAssembled</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EPMCurEstdCapct</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMCurEstdCapct</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EPMMaxEstdCapct</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMMaxEstdCapct</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EPMOprtMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMOprtMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EPTToqCustSetngReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTToqCustSetngReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EPTToqCustSetngReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTToqCustSetngReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EnrgSplReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EnrgSplReqRaw</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReqRaw</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/EnrgSplReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/ICBVC_100ms_Group19_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/ICBVC_100ms_Group19_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/ICBVC_100ms_Group19_Reserved21</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved21</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/ICBVC_100ms_Group19_Reserved35</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved35</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/ICBVC_100ms_Group19_Reserved58</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved58</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBMDisChrgMOSCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBMDisChrgMOSCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBatChrgReqInhbt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatChrgReqInhbt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBatChrgReqRaw</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatChrgReqRaw</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBatEnrgLow</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatEnrgLow</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBatEnrgSufct</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatEnrgSufct</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/LVBatSelfWakeupFlg</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatSelfWakeupFlg</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/PMDCSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PMDCSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/RgnLvReqFICM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/RgnLvReqFICMV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICMV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/VehEnrgRdyLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group19/VehEnrgRdyLvlV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvlV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_100ms_Group80</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group80/ICBVC_100ms_Group80</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group80</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/FrtPsngAirbagSwStsReqV_Sfty</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagSwStsReqV_Sfty</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/FrtPsngAirbagSwStsReq_Sfty</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagSwStsReq_Sfty</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/ICBVC_100ms_Group80_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/ICBVC_100ms_Group80_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/ICBVC_100ms_Group80_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/ICBVC_100ms_Group80_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/ICBVC_100ms_Group80_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/VehDrvngMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDrvngMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/VehLdShedLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehLdShedLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/VehOdo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_100ms_Group80/VehOdoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_200ms_Group79</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_200ms_Group79/ICBVC_200ms_Group79</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_200ms_Group79</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/ClstrDspdAirbagWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClstrDspdAirbagWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/EPTNotReadyReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTNotReadyReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/ICBVC_200ms_Group79_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/ICBVC_200ms_Group79_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/ICBVC_200ms_Group79_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/ICBVC_200ms_Group79_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/OdoPriyPrcs</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OdoPriyPrcs</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/OdoPriyPrcsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OdoPriyPrcsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_200ms_Group79/TrlrMdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrlrMdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_20ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_20ms_Group03/ICBVC_20ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_20ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/AMRPrtensonReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AMRPrtensonReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/BPMMstrAvlbly</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BPMMstrAvlbly</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/ICBVC_20ms_Group03_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/PwrMdMstrAccryA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdMstrAccryA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/PwrMdMstrRunCrkA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdMstrRunCrkA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysOpnlMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysOpnlMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysPwrMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysPwrMdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysVolMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysVolMdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/SysVolV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/UsgMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/UsgMdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/VehMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_20ms_Group03/VehMdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group11/ICBVC_50ms_Group11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group11</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsCanclSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCanclSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsDistDecSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistDecSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsDistIncSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistIncSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsOnSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsOnSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsRsmSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsRsmSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsSpdDecSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdDecSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsSpdIncSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdIncSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/CCSwStsSwDataIntgty</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSwDataIntgty</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/HMISafFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HMISafFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/ICBVC_50ms_Group11_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/PfTrTapUpDwnEnbSwSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnEnbSwSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/PfTrTapUpDwnSecySwSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnSecySwSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/PfTrTapUpDwnSwSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnSwSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SWSCnfmSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SWSSelDwnSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelDwnSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SWSSelLSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SWSSelRSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SWSSelUpSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelUpSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/StrgWhlTipcSwDataIntgty</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlTipcSwDataIntgty</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/SwStaE2EErr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SwStaE2EErr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/TrPfShftPtrnSw1A</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw1A</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/TrPfShftPtrnSw2A</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw2A</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/TrPfShftPtrnSw3A</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw3A</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group11/TrPfShftPtrnSw4A</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw4A</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group13/ICBVC_50ms_Group13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group13</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/AutocParkngSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocParkngSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/FLDircnLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/FRDircnLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/FrSsdManuCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrSsdManuCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved16</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved16</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/ICBVC_50ms_Group13_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/IMATESysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMATESysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/PwrMdCtrlResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdCtrlResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/SpdLmtMdFICM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdFICM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group13/TgtParkingChosed</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TgtParkingChosed</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group158</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group158/ICBVC_50ms_Group158</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group158</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCDisAdjtVcCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisAdjtVcCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCDisDecAndIncVcCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCSpdDecAndIncVcCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCSpdVcCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCSpdVcCmdSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmdSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCSwStsCCASwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCCASwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/CCSwStsSetSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSetSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group158/ICBVC_50ms_Group158_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBVC_50ms_Group256</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group256/ICBVC_50ms_Group256</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group256</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/DMSSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DMSSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved100</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved100</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved85</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved85</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/ICBVC_50ms_Group256_Reserved96</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved96</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoadCrvt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoadCrvtDist</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvtDist</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoadSlope</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlope</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoadSlopeDist</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlopeDist</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoughRoaddetection</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetection</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/RoughRoaddetectionDist</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetectionDist</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSCnfmSwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSLFnChngSwA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSLFnChngSwA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSPB1SwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB1SwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSPB2SwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB2SwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSPB3SwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB3SwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSSelLSwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/SWSSelRSwStuckL</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwStuckL</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBVC_50ms_Group256/VehboardSetting</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehboardSetting</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IMM_50ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IMM_50ms_Group02/IMM_50ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IMM_50ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DMSSts_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DMSSts_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrAbnormBehvor_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrAbnormBehvor_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrAbnormConf_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrAbnormConf_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrDstcnConf_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnConf_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrDstcnStsINST_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnStsINST_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrDstcnSts_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnSts_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrFtgConf_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgConf_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrFtgLvlINST_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgLvlINST_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrFtgLvl_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgLvl_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrGazeRgn_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrGazeRgn_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/DrvrPrst_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrPrst_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/EyeGazepitch_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeGazepitch_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/EyeGazeyaw_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeGazeyaw_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/EyeOnRoad_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOnRoad_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/EyeOpenDegree_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOpenDegree_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/EyeOpenStatus_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOpenStatus_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/ILBRReq_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILBRReq_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved143</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved143</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved151</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved151</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved159</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved159</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/IMM_50ms_Group02_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/LeftEyeOccludeStatus_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LeftEyeOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/MouthOccludeStatus_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MouthOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/OMSSts_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OMSSts_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/RightEyeOccludeStatus_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RightEyeOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/SpfngDet_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpfngDet_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IMM_50ms_Group02/YawnStatus_IMM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/YawnStatus_IMM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group43</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group43/IPD_20ms_Group43</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group43</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/ACCAccReqToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/ACCSysFltSts_SCS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts_SCS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/FrtCarGoNotfr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCarGoNotfr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group43/IPD_20ms_Group43_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group60</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group60/IPD_20ms_Group60</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group60</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ALCSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ALCSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/APASCSToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/APAVehCrdnatAzmth</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatAzmth</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/APAVehCrdnatPosX</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosX</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/APAVehCrdnatPosY</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosY</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/AutoLaneChngLLaneSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngLLaneSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/AutoLaneChngRLaneSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngRLaneSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ESSDirInd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSDirInd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ESSDrvrTkovReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSDrvrTkovReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ESSSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/ESSSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/IPD_20ms_Group60_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/NOPSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/NOPSysSts_ZPD</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSysSts_ZPD</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/Parkngslottype</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Parkngslottype</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/PilotTkovMsgReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotTkovMsgReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group60/PrkgDstCtrlSwResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PrkgDstCtrlSwResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group64</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group64/IPD_20ms_Group64</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group64</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APAEnToqReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APAEnToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSBrkFn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSBrkFnMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFnMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSDrvrReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSDrvrReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSParkngPrflReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngPrflReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSParkngTrgtDist</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngTrgtDist</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSParkngVelMax</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngVelMax</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/APASCSReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group64/IPD_20ms_Group64_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_20ms_Group67</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_20ms_Group67/IPD_20ms_Group67</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group67</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/ADS_SpdAstSysTrgtSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/ADS_SpdAstSysTrgtSpdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_20ms_Group67/IPD_20ms_Group67_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_50ms_Group14</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_50ms_Group14/IPD_50ms_Group14</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_50ms_Group14</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/IPD_50ms_Group14_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/LADSInfoDispReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSInfoDispReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/LADSInfoDispReqToICM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSInfoDispReqToICM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/LADSProgressBar</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSProgressBar</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/SDWLSFObsRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSFObsRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/SDWLSRObsRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSRObsRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/SDWRSFObsRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSFObsRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group14/SDWRSRObsRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSRObsRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_50ms_Group49</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_50ms_Group49/IPD_50ms_Group49</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_50ms_Group49</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/APAEnRunReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnRunReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/IPD_50ms_Group49_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/KeepPwrRsnIPD</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/KeepPwrRsnIPD</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/LADSAFnInd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSAFnInd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_50ms_Group49/SysPwrMdCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_Sporadic_TimeSync_Group</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_Sporadic_TimeSync_Group/IPD_Sporadic_TimeSync_Group</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_Sporadic_TimeSync_Group</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgCheckSum</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgCheckSum</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgOVS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgOVS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgSGW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSGW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgSequenceCounter</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSequenceCounter</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgTime</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTime</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgTimeDomain</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTimeDomain</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgType</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgType</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IPD_Sporadic_TimeSync_Group/SyncMsgreserved</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgreserved</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_100ms_Group30</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_100ms_Group30/LHZCU_100ms_Group30</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_100ms_Group30</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/DircnIndLampSwStsMntry</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnIndLampSwStsMntry</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/FLSeatHorzPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatHorzPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/FLSeatVertPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatVertPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved87</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved87</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_100ms_Group30/LHZCU_100ms_Group30_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group01/LHZCU_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/DigKeyAuthReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DigKeyAuthReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/DigKeyPEValidReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DigKeyPEValidReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/DrvrReqParkBtn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqParkBtn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/KeyAuthResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/KeyAuthResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/LHZCU_10ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/LHZCU_10ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/LHZCU_10ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/LHZCU_10ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUAPAUnderCtrlActv</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUAPAUnderCtrlActv</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUDrvMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUDrvrIntrvnActv</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvrIntrvnActv</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUExtdShiftrFlr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShiftrFlr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUFltLvlWarn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUFltLvlWarn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUParkLckReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUParkLckReqEPMCU</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqEPMCU</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUParkLckReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUParkLckReqVEPMCU</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqVEPMCU</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUShiftrLvrPosn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUShiftrLvrPosnLtchActv</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosnLtchActv</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUShiftrLvrRawPosn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrRawPosn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUShiftrOpngRmndr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrOpngRmndr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SCUShiftrPosnInvsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrPosnInvsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group01/SecuKeyVldSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecuKeyVldSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_10ms_Group32</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group32/LHZCU_10ms_Group32</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_10ms_Group32</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/BrkLghtSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/DircnLghtOnReq_LHZCU</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtOnReq_LHZCU</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/DrvrReqGearShftPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqGearShftPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/DrvrReqGearShftPosInvs</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqGearShftPosInvs</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/EleccTrRngReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EleccTrRngReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LDayTimeRunningLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDayTimeRunningLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCUWKSTS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCUWKSTS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/LHZCU_10ms_Group32_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/MainBeamLghtSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MainBeamLghtSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/RDayTimeRunningLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDayTimeRunningLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/RrFogLightOnReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLightOnReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUActrMvmntSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUActrMvmntSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUDrvnIntrvnPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvnIntrvnPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUExtdShifterActrPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShifterActrPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUParkActrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkActrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUShftLvrPosIncnstntFlag</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosIncnstntFlag</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUShftLvrPosTrgt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosTrgt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUTapUpDwnSwSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SCUTapUpDwnSwStaInvsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwStaInvsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SideLghtOnReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SideLghtOnReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SmrtKey4LoctnResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey4LoctnResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SmrtKeyLoctnFlrRsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnFlrRsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_10ms_Group32/SmrtKeyLoctnProc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnProc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_20ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_20ms_Group03/LHZCU_20ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_20ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/BrkLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/DippedBeamActStatus</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DippedBeamActStatus</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/FLDircnLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/FRDircnLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/HzrdLghtSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HzrdLghtSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LHZCU_20ms_Group03_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/LMainBeamLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LMainBeamLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/PriySSBA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PriySSBA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/PriySSBAV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PriySSBAV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/RLDircnLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/RMainBeamLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMainBeamLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/RRDircnLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/RevsLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/SSBTrigd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SSBTrigd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/SecySSBA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_20ms_Group03/SecySSBAV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBAV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_400ms_Group18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_400ms_Group18/LHZCU_400ms_Group18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_400ms_Group18</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/LHZCU_400ms_Group18_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/TPMSF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_400ms_Group18/TPMSTirePrsLowIO</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSTirePrsLowIO</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_50ms_Group06</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group06/LHZCU_50ms_Group06</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_50ms_Group06</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/BntOpenSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BntOpenSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/DirnLghtSftyMonErr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DirnLghtSftyMonErr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/DrvrDetSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDetSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/DrvrDoorOpenSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDoorOpenSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/LHZCU_50ms_Group06_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group06_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/RLDoorOpenSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDoorOpenSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/RLSInitnFltPrst</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSInitnFltPrst</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group06/VehLckSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehLckSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_50ms_Group24</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group24/LHZCU_50ms_Group24</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_50ms_Group24</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/BrkLghtFltSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtFltSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/BrkLghtSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/DircnLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/DircnLghtMdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtMdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/DircnLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/DircnLghtSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/HUDLkngAmbtLghtLvlByLux</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HUDLkngAmbtLghtLvlByLux</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved121</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved121</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved135</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved135</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved143</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved143</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved151</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved151</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved159</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved159</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved49</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved49</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved60</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved60</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved81</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved81</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved87</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved87</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/LHZCU_50ms_Group24_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_50ms_Group24_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/RLSideLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSideLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/RRSideLghtCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSideLghtCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/VehHzrdMdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehHzrdMdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/VehIlluminateCtrlCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehIlluminateCtrlCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/LHZCU_50ms_Group24/VehSideLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSideLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEU_10ms_Group25</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEU_10ms_Group25/PEU_10ms_Group25</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PEU_10ms_Group25</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotADampTrqCmdd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotADampTrqCmdd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotAMdAch</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotAMdAch</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotASpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotASpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotASpdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotASpdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotASpdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotASpdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotAToqAch</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotAToqAch</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotAToqAchV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotAToqAchV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBDampTrqCmdd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBDampTrqCmdd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBMdAch</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBMdAch</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBSpdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBSpdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBSpdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBSpdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBToqAch</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBToqAch</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEUMotBToqAchV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEUMotBToqAchV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEU_10ms_Group25_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEU_10ms_Group25_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEU_10ms_Group25_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEU_10ms_Group25_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEU_10ms_Group25_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEU_10ms_Group25_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEU_10ms_Group25_Reserved147</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEU_10ms_Group25_Reserved147</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/PEU_10ms_Group25_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEU_10ms_Group25_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/ReAxleMaxAvlblWhlDrvTq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlDrvTq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/ReAxleMaxAvlblWhlDrvTqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlDrvTqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/ReAxleMaxAvlblWhlRgtnTq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlRgtnTq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PEU_10ms_Group25/ReAxleMaxAvlblWhlRgtnTqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlRgtnTqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_10ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_10ms_Group03/PICU_10ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_10ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/DrvrReqFrtAxleWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqFrtAxleWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/DrvrReqFrtAxleWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqFrtAxleWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/DrvrReqRrAxleWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqRrAxleWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/DrvrReqRrAxleWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqRrAxleWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/FrtAxleActuWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtAxleActuWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/FrtAxleActuWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtAxleActuWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PICU_10ms_Group03_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group03_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/PtHVCntarReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PtHVCntarReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/RrAxleActuWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrAxleActuWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/RrAxleActuWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrAxleActuWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/TotActuWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TotActuWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group03/TotActuWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TotActuWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_10ms_Group23</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_10ms_Group23/PICU_10ms_Group23</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_10ms_Group23</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/CrkshftNonTrRegdCmddToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CrkshftNonTrRegdCmddToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnComFlrRducdPwrCmdd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnComFlrRducdPwrCmdd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnDclFuelCutOffAld</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnDclFuelCutOffAld</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnDclFuelCutOffReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnDclFuelCutOffReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnDclFuelCutOffSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnDclFuelCutOffSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnFuelCutA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnFuelCutA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnFuelRcvrySpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnFuelRcvrySpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnHybVehStaOvrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnHybVehStaOvrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnIdleCtrlA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIdleCtrlA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnIdleCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIdleCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnReqdStTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnReqdStTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnStCtrlA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnStCtrlA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnSynRdy</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSynRdy</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/EnSysDsbld</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSysDsbld</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/HybEnSpdReqF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HybEnSpdReqF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/HybEnStSpOvrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HybEnStSpOvrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/PICU_10ms_Group23_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group23_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/PICU_10ms_Group23_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group23_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/PICU_10ms_Group23_Reserved18</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_10ms_Group23_Reserved18</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/PtACCA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PtACCA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_10ms_Group23/RVSEnRunning</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSEnRunning</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_20ms_Group11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_20ms_Group11/PICU_20ms_Group11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_20ms_Group11</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/CstRgtnBrkLgtReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CstRgtnBrkLgtReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/CstRgtnBrkLgtReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CstRgtnBrkLgtReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/HybAPAAvlbl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HybAPAAvlbl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/MaxAvlblTotWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MaxAvlblTotWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/MaxAvlblTotWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MaxAvlblTotWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/MinAvlblTotWhlToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MinAvlblTotWhlToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/MinAvlblTotWhlToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MinAvlblTotWhlToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/PICU_20ms_Group11_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_20ms_Group11_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/RdundtHybCmddEnToqImmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqImmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/RdundtHybCmddEnToqPrdtd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqPrdtd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/PICU_20ms_Group11/RdundtHybCmddEnToqRespTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqRespTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFSDA_20ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFSDA_20ms_Group02/RFSDA_20ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RFSDA_20ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/AEBDclReqSts_ADAS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqSts_ADAS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/AEBDclReqToqVal_ADAS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqToqVal_ADAS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/AEBDclReqVal_ADAS</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqVal_ADAS</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RFSDA_20ms_Group02/RFSDA_20ms_Group02_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFSDA_20ms_Group02_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHRDA_50ms_Group04</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHRDA_50ms_Group04/RHRDA_50ms_Group04</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHRDA_50ms_Group04</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/BSDSelSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BSDSelSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/DOWSelSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DOWSelSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/LBSDAndLCAWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LBSDAndLCAWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/LCASelSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LCASelSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/LDOWWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDOWWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/LRCTAWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LRCTAWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RBSDAndLCAWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RBSDAndLCAWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RCTSysSelSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RCTSysSelSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RDASwSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDASwSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RDASysSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDASysSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RDOWWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDOWWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RHRDA_50ms_Group04_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHRDA_50ms_Group04_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RLRdrEmgcLineChngWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLRdrEmgcLineChngWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RRCTAWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRCTAWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RRRdrEmgcLineChngWrnng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRRdrEmgcLineChngWrnng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHRDA_50ms_Group04/RrCrnRdrCalSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrCrnRdrCalSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_100ms_Group10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_100ms_Group10/RHZCU_100ms_Group10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_100ms_Group10</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/ACAmbtTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/ACAmbtTemMsk</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTemMsk</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/ACAmbtTemV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTemV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/ACComprActuPwr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACComprActuPwr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/FRSeatHorzPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatHorzPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/FRSeatVertPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatVertPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_100ms_Group10/RHZCU_100ms_Group10_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_100ms_Group10_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_50ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group01/RHZCU_50ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_50ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCU_50ms_Group01_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCUeSw41DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw41DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RHZCUeSw41Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw41Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group01/RRDoorOpenSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDoorOpenSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_50ms_Group27</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group27/RHZCU_50ms_Group27</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_50ms_Group27</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCU_50ms_Group27_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCU_50ms_Group27_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw33DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw33DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw33Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw33Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw37DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw37DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw37Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw37Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw3DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw3DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw3Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw3Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw42DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw42DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw42Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw42Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw43DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw43DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw43Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw43Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw9DiagSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw9DiagSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RHZCU_50ms_Group27/RHZCUeSw9Sts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeSw9Sts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_100ms_Group10</CONTEXT-PORT-REF>
