                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group13_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group13_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACCBrkngA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysMdReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngSysMdReqRespV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChACCAccReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChACCReqFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChAEBBrkJerkReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChAEBDclReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChAEBHydBrkAstReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChAEBPrflReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChRCTBDclReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChRCTBPrflReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ExtnlBrkPrio</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ExtnlBrkPrioV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBSAPASysFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSAPAAcclA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSAPAAcclAV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSAutodDrvngSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSAutodDrvngSysStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSVehHoldA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCSVehHoldAV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSdslSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSdslStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlBrkPrsSts</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChEBADclReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb900a00">
                  <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250929_D5X-博伟需求-路由.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_CHAvlbly/IBS_CHAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_CHAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_CHAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8d8f00">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250630_工作簿1.xlsx_BrkBstFnSts
20250630_工作簿1.xlsx_EPBAppcnSts_M
20250630_工作簿1.xlsx_IBSRespAccToqVal
20250630_工作簿1.xlsx_IBS_ZONE_20ms_Group08_CRC
20250630_工作簿1.xlsx_IBS_ZONE_20ms_Group08_RC
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBSRespAccToqVal
20260706_modify.xlsx_IBSRespAccToqVal
20260707_modify.xlsx_BrkBstFnSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_ZONE_20ms_Group08</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkBstFnSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBAppcnSts_M</SHORT-LABEL>
                              <VALUE>0x2</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBSRespAccToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_ZONE_20ms_Group08_Reserved5</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_ZONE_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb03a200">
                  <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_ClstrDspdVehSpd
20260706_modify.xlsx_DspMeasmtSys
20260706_modify.xlsx_FLSeatHeatCtrlSts
20260706_modify.xlsx_MdOfPwrMd
20260706_modify.xlsx_PDCSwReq
20260706_modify.xlsx_PwrMdExtrCtrlAvlbl
20260710_C1.xlsx_FRSeatHeatCtrlSts
20260710_C1.xlsx_FLSeatVentCtrlSts
20260710_C1.xlsx_FRSeatVentCtrlSts
20260715_modify.xlsx_ClstrDspdVehSpd</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group01/ICBVC_100ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_100ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ClstrDspdVehSpd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DspMeasmtSys</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLSeatHeatCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MdOfPwrMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PDCSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PwrMdExtrCtrlAvlbl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRSeatHeatCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLSeatVentCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRSeatVentCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved21</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved31</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved47</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved79</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved72</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved84</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved80</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved92</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group01_Reserved14</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb0b6600">
                  <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_EPMCurEstdCapct
20260706_modify.xlsx_EPMMaxEstdCapct
20260706_modify.xlsx_EPMOprtMd
20260706_modify.xlsx_EPTToqCustSetngReq
20260706_modify.xlsx_EPTToqCustSetngReqV
20260706_modify.xlsx_EnrgSplReq
20260706_modify.xlsx_EnrgSplReqRaw
20260706_modify.xlsx_EnrgSplReqV
20260706_modify.xlsx_LVBatChrgReqInhbt
20260706_modify.xlsx_LVBatChrgReqRaw
20260706_modify.xlsx_LVBatEnrgLow
20260706_modify.xlsx_LVBatEnrgSufct
20260706_modify.xlsx_LVBatSelfWakeupFlg
20260706_modify.xlsx_PMDCSta
20260706_modify.xlsx_RgnLvReqFICM
20260706_modify.xlsx_RgnLvReqFICMV
20260706_modify.xlsx_VehEnrgRdyLvl
20260706_modify.xlsx_VehEnrgRdyLvlV
20260713_C1.xlsx_AuxBatUnAssembled
20260713_C1.xlsx_LVBMDisChrgMOSCtrl
20260720_C1.xlsx_EnrgSplReq
20260720_C1.xlsx_EnrgSplReqV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group19/ICBVC_100ms_Group19</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_100ms_Group19</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPMCurEstdCapct</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPMMaxEstdCapct</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPMOprtMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTToqCustSetngReq</SHORT-LABEL>
                              <VALUE>0x2</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTToqCustSetngReqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnrgSplReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnrgSplReqRaw</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnrgSplReqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBatChrgReqInhbt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBatChrgReqRaw</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBatEnrgLow</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBatEnrgSufct</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBatSelfWakeupFlg</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PMDCSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RgnLvReqFICM</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RgnLvReqFICMV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehEnrgRdyLvl</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehEnrgRdyLvlV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AuxBatUnAssembled</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LVBMDisChrgMOSCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group19_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group19_Reserved21</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group19_Reserved35</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group19_Reserved58</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group19_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba14000">
                  <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_FrtPsngAirbagSwStsReqV_Sfty
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_FrtPsngAirbagSwStsReq_Sfty
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_100ms_Group80_CRC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_100ms_Group80_RC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_100ms_Group80_Reserved1
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_100ms_Group80_Reserved2
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_100ms_Group80_Reserved3
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehDrvngMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehLdShedLvl
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehOdo
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehOdoV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehDrvngMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehLdShedLvl
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehOdo
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehOdoV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehDrvngMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehLdShedLvl
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehOdo
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehOdoV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_FrtPsngAirbagSwStsReqV_Sfty
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_FrtPsngAirbagSwStsReq_Sfty
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ICBVC_100ms_Group80_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ICBVC_100ms_Group80_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehDrvngMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehLdShedLvl
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehOdo
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehOdoV
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehDrvngMd
20260506_20260506-AS5PR EV-PPV-V1.2.xlsx_VehDrvngMd
20260703_modify.xlsx_VehDrvngMd
20260706_modify.xlsx_VehOdo</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group80/ICBVC_100ms_Group80</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_100ms_Group80</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehDrvngMd</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehLdShedLvl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehOdo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehOdoV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group80_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group80_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagSwStsReqV_Sfty</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagSwStsReq_Sfty</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group80_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group80_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_100ms_Group80_Reserved3</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group80</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba16700">
                  <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ClstrDspdAirbagWrnng
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_EPTNotReadyReq
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_200ms_Group79_CRC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_200ms_Group79_RC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_OdoPriyPrcs
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_OdoPriyPrcsV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_TrlrMdsts
20260703_modify.xlsx_OdoPriyPrcs
20260703_modify.xlsx_OdoPriyPrcsV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_200ms_Group79/ICBVC_200ms_Group79</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_200ms_Group79</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTNotReadyReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OdoPriyPrcs</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OdoPriyPrcsV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_200ms_Group79_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_200ms_Group79_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ClstrDspdAirbagWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrlrMdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_200ms_Group79_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_200ms_Group79_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_200ms_Group79</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba18e00">
                  <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_AMRPrtensonReq
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_BPMMstrAvlbly
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_CRC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_RC
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_Reserved1
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_Reserved2
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_Reserved3
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ICBVC_20ms_Group03_Reserved4
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_PwrMdMstrAccryA
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_PwrMdMstrRunCrkA
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysOpnlMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysPwrMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysPwrMdV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysVol
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysVolMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysVolMdV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_SysVolV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_UsgMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_UsgMdV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehMd
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_VehMdV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysOpnlMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysPwrMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysPwrMdV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysVol
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysVolMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysVolMdV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_SysVolV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_UsgMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_UsgMdV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehMd
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehMdV
20251231_export.xlsx_UsgMd
20251231_export.xlsx_UsgMdV
20251231_export.xlsx_VehMd
20251231_export.xlsx_VehMdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AMRPrtensonReq
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BPMMstrAvlbly
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_CRC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_RC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_Reserved1
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_Reserved2
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_Reserved3
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ICBVC_20ms_Group03_Reserved4
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PwrMdMstrAccryA
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PwrMdMstrRunCrkA
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysOpnlMd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysPwrMd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysPwrMdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVol
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolMd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolMdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_UsgMd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_UsgMdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehMd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehMdV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PwrMdMstrAccryA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PwrMdMstrRunCrkA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysOpnlMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysPwrMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysPwrMdV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVol
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolMdV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_SysVolV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_UsgMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_UsgMdV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehMdV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_AMRPrtensonReq
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_BPMMstrAvlbly
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ICBVC_20ms_Group03_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ICBVC_20ms_Group03_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_PwrMdMstrAccryA
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_PwrMdMstrRunCrkA
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysOpnlMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysPwrMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysPwrMdV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysVol
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysVolMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysVolMdV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_SysVolV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_UsgMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_UsgMdV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehMd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehMdV
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_UsgMd
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_UsgMdV
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehMd
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehMdV
20260506_20260506-AS5PR EV-PPV-V1.2.xlsx_UsgMd
20260506_20260506-AS5PR EV-PPV-V1.2.xlsx_UsgMdV
20260528_新增接收.xlsx_UsgMd
20260528_新增接收.xlsx_UsgMdV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_20ms_Group03/ICBVC_20ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_20ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>UsgMd</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AMRPrtensonReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BPMMstrAvlbly</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PwrMdMstrAccryA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PwrMdMstrRunCrkA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysOpnlMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysPwrMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysPwrMdV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysVolMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysVolMdV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SysVolV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>UsgMdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehMdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_20ms_Group03_Reserved4</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb8a42500">
                  <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_CCSwStsSpdIncSwA</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group11/ICBVC_50ms_Group11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_50ms_Group11</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsCanclSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsDistDecSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsDistIncSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsOnSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsRsmSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsSpdDecSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsSpdIncSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsSwDataIntgty</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSCnfmSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelDwnSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelLSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelRSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelUpSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PfTrTapUpDwnEnbSwSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PfTrTapUpDwnSecySwSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PfTrTapUpDwnSwSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlTipcSwDataIntgty</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPfShftPtrnSw1A</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPfShftPtrnSw2A</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPfShftPtrnSw3A</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPfShftPtrnSw4A</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SwStaE2EErr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HMISafFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved4</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved5</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group11_Reserved6</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9eb600">
                  <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251219_20251217-D5X EV软件层需求.xlsx_AutocParkngSwReq
20251219_20251217-D5X EV软件层需求.xlsx_FLDircnLghtFltsts
20251219_20251217-D5X EV软件层需求.xlsx_FRDircnLghtFltsts
20251219_20251217-D5X EV软件层需求.xlsx_PwrMdCtrlResp
20251219_20251217-D5X EV软件层需求.xlsx_SpdLmtMdFICM
20251219_20251217-D5X EV软件层需求.xlsx_TgtParkingChosed
20260105_AS5P EP PHEV 20260105导出.xlsx_IMATESysSts
20260703_modify.xlsx_TgtParkingChosed
20260706_modify.xlsx_IMATESysSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group13/ICBVC_50ms_Group13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_50ms_Group13</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrSsdManuCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutocParkngSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLDircnLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRDircnLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PwrMdCtrlResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SpdLmtMdFICM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TgtParkingChosed</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMATESysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved4</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved6</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved9</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved10</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved11</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved12</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved14</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved15</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group13_Reserved16</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8ad200">
                  <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_加Group-蓝色-梳理.xlsx_ICBVC_30ms_Group158_CRC
20250625_加Group-蓝色-梳理.xlsx_ICBVC_30ms_Group158_RC
20250625_加Group-蓝色-梳理.xlsx_CCDisDecAndIncVcCmd
20250625_加Group-蓝色-梳理.xlsx_CCSpdDecAndIncVcCmd
20250625_加Group-蓝色-梳理.xlsx_CCSpdVcCmdSwReq
20250625_加Group-蓝色-梳理.xlsx_CCSwStsCCASwA
20250625_加Group-蓝色-梳理.xlsx_CCSwStsSetSwA
20251210_D5X EV 对比信号需求.xlsx_CCDisAdjtVcCmd
20251210_D5X EV 对比信号需求.xlsx_CCSpdVcCmd
20260706_modify.xlsx_CCSwStsCCASwA
20260706_modify.xlsx_CCSwStsSetSwA</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group158/ICBVC_50ms_Group158</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_50ms_Group158</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCDisDecAndIncVcCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSpdDecAndIncVcCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSpdVcCmdSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsCCASwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSwStsSetSwA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCDisAdjtVcCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCSpdVcCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved3</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group158_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group158</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8ebf00">
                  <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250818_加Group.xlsx_DMSSts
20250818_加Group.xlsx_SWSCnfmSwStuckL
20250818_加Group.xlsx_SWSPB1SwStuckL
20250818_加Group.xlsx_SWSPB2SwStuckL
20250818_加Group.xlsx_SWSPB3SwStuckL
20250818_加Group.xlsx_SWSSelLSwStuckL
20250818_加Group.xlsx_SWSSelRSwStuckL
20250818_加Group.xlsx_ICBVC_50ms_Group256_CRC
20250818_加Group.xlsx_ICBVC_50ms_Group256_RC
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_SWSLFnChngSwA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehboardSetting</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group256/ICBVC_50ms_Group256</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICBVC_50ms_Group256</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DMSSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoadCrvt</SHORT-LABEL>
                              <VALUE>0x20000</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoadCrvtDist</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoadSlope</SHORT-LABEL>
                              <VALUE>0x800</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoadSlopeDist</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoughRoaddetectionDist</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSCnfmSwStuckL</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSLFnChngSwA</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSPB1SwStuckL</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSPB2SwStuckL</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSPB3SwStuckL</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelLSwStuckL</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SWSSelRSwStuckL</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RoughRoaddetection</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehboardSetting</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved85</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved103</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved100</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved96</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ICBVC_50ms_Group256_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group256</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9f9c00">
                  <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrDstcnSts/ICMDrvrDstcnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMDrvrDstcnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrDstcnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9fc300">
                  <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrFtgLvl/ICMDrvrFtgLvl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMDrvrFtgLvl</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9fea00">
                  <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrPrst/ICMDrvrPrst</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMDrvrPrst</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba01100">
                  <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMEyeOnRoad/ICMEyeOnRoad</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMEyeOnRoad</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMEyeOnRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f3a1b413220e8600">
                  <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260707_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve16/ICMSwReq_Reserve16</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMSwReq_Reserve16</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f3a1b413220fd800">
                  <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260707_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve17/ICMSwReq_Reserve17</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ICMSwReq_Reserve17</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb293800">
                  <SHORT-NAME>ILCSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ILCSwReq/ILCSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ILCSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ILCSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbc3900">
                  <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260602_修改导入表.xlsx_DMSSts_IMM
20260602_修改导入表.xlsx_DrvrAbnormBehvor_IMM
20260602_修改导入表.xlsx_DrvrAbnormConf_IMM
20260602_修改导入表.xlsx_DrvrDstcnConf_IMM
20260602_修改导入表.xlsx_DrvrDstcnStsINST_IMM
20260602_修改导入表.xlsx_DrvrDstcnSts_IMM
20260602_修改导入表.xlsx_DrvrFtgConf_IMM
20260602_修改导入表.xlsx_DrvrFtgLvlINST_IMM
20260602_修改导入表.xlsx_DrvrFtgLvl_IMM
20260602_修改导入表.xlsx_DrvrGazeRgn_IMM
20260602_修改导入表.xlsx_DrvrPrst_IMM
20260602_修改导入表.xlsx_EyeGazepitch_IMM
20260602_修改导入表.xlsx_EyeGazeyaw_IMM
20260602_修改导入表.xlsx_EyeOnRoad_IMM
20260602_修改导入表.xlsx_EyeOpenDegree_IMM
20260602_修改导入表.xlsx_EyeOpenStatus_IMM
20260602_修改导入表.xlsx_Headpose_pitch
20260602_修改导入表.xlsx_Headpose_roll
20260602_修改导入表.xlsx_Headpose_yaw
20260602_修改导入表.xlsx_ILBRReq_IMM
20260602_修改导入表.xlsx_IMM_50ms_Group02_CRC
20260602_修改导入表.xlsx_IMM_50ms_Group02_RC
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved103
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved111
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved119
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved127
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved135
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved143
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved15
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved151
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved159
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved167
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved175
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved183
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved191
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved73
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved84
20260602_修改导入表.xlsx_IMM_50ms_Group02_Reserved95
20260602_修改导入表.xlsx_LeftEyeOccludeStatus_IMM
20260602_修改导入表.xlsx_MouthOccludeStatus_IMM
20260602_修改导入表.xlsx_OMSSts_IMM
20260602_修改导入表.xlsx_RightEyeOccludeStatus_IMM
20260602_修改导入表.xlsx_SpfngDet_IMM
20260602_修改导入表.xlsx_YawnStatus_IMM
20260703_modify.xlsx_DMSSts_IMM</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IMM_50ms_Group02/IMM_50ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IMM_50ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OMSSts_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ILBRReq_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrDstcnStsINST_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrFtgLvlINST_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DMSSts_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrAbnormBehvor_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrDstcnSts_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrFtgLvl_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrGazeRgn_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrPrst_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeOnRoad_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SpfngDet_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrFtgConf_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrDstcnConf_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrAbnormConf_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeOpenStatus_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LeftEyeOccludeStatus_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RightEyeOccludeStatus_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>YawnStatus_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MouthOccludeStatus_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeGazepitch_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeGazeyaw_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EyeOpenDegree_IMM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved3</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved5</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved6</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved7</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved143</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved151</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMM_50ms_Group02_Reserved159</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMM_50ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8d1a00">
                  <SHORT-NAME>IMU_SN</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250626_加Group-添加周期.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IMU_SN/IMU_SN</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <ARRAY-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IMU_SN</SHORT-LABEL>
                          <ELEMENTS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6579</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6580</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6581</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6582</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6583</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6584</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6585</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6586</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6587</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6588</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6589</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Generic_Literal6590</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </ELEMENTS>
                        </ARRAY-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMU_SN</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7a8f00">
                  <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250611_IP5PM EP信号需求V7-梳理.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPowerFailSwReq/IPDPowerFailSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IPDPowerFailSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPowerFailSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb835d00">
                  <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGMaxTqLmt_Nm/ISGMaxTqLmt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ISGMaxTqLmt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMaxTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb838400">
                  <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGMinTqLmt_Nm/ISGMinTqLmt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ISGMinTqLmt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMinTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb83ab00">
                  <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGTqTgt_Nm/ISGTqTgt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ISGTqTgt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGTqTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5e8900">
                  <SHORT-NAME>IdentityChlg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IdentityChlg/IdentityChlg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IdentityChlg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IdentityChlg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5c7400">
                  <SHORT-NAME>IgnOffTime</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250526_IP5PM EP信号需求V4---梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IgnOffTime/IgnOffTime</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IgnOffTime</SHORT-LABEL>
                          <VALUE>0xFFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTime</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5c9b00">
                  <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250526_IP5PM EP信号需求V4---梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IgnOffTimeV/IgnOffTimeV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IgnOffTimeV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTimeV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb633400">
                  <SHORT-NAME>LCASelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCASelReq/LCASelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LCASelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCASelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb650800">
                  <SHORT-NAME>LCRSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRSwReq/LCRSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LCRSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb295f00">
                  <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250311_PT信号总表.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWAdoWrnngReq/LDWAdoWrnngReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LDWAdoWrnngReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb298600">
                  <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWLKAHptWrnngReq/LDWLKAHptWrnngReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LDWLKAHptWrnngReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKAHptWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb29ad00">
                  <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWLKASwReq/LDWLKASwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LDWLKASwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb29d400">
                  <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWSnstvtLvlReq/LDWSnstvtLvlReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LDWSnstvtLvlReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9bf200">
                  <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LFCTWrnng_ADAS/LFCTWrnng_ADAS</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LFCTWrnng_ADAS</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb618800">
                  <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHSWPwrSts/LHSWPwrSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHSWPwrSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHSWPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8b4700">
                  <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_MG6 PHEVEV 高配 有效性信号需求.xlsx
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCUAvlbly/LHZCUAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCUAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9cd000">
                  <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_DircnIndLampSwStsMntry
20251219_D5X EV 对比信号需求-2021219.xlsx_DircnIndLampSwStsMntry
20260226_20260226-新增信号需求.xlsx_DircnIndLampSwStsMntry
20260706_modify.xlsx_DircnIndLampSwStsMntry</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_100ms_Group30/LHZCU_100ms_Group30</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_100ms_Group30</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLSeatHorzPos</SHORT-LABEL>
                              <VALUE>0xFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLSeatVertPos</SHORT-LABEL>
                              <VALUE>0xFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnIndLampSwStsMntry</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved12</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved31</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved79</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved87</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_100ms_Group30_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_100ms_Group30</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbc6100">
                  <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260605_AS5PR EV增补.xlsx_DigKeyAuthReq
20260605_AS5PR EV增补.xlsx_DigKeyPEValidReq
20260605_AS5PR EV增补.xlsx_DrvrReqParkBtn
20260605_AS5PR EV增补.xlsx_KeyAuthResp
20260605_AS5PR EV增补.xlsx_LHZCU_10ms_Group01_CRC
20260605_AS5PR EV增补.xlsx_LHZCU_10ms_Group01_RC
20260605_AS5PR EV增补.xlsx_SCUAPAUnderCtrlActv
20260605_AS5PR EV增补.xlsx_SCUDrvMd
20260605_AS5PR EV增补.xlsx_SCUDrvrIntrvnActv
20260605_AS5PR EV增补.xlsx_SCUExtdShiftrFlr
20260605_AS5PR EV增补.xlsx_SCUFltLvlWarn
20260605_AS5PR EV增补.xlsx_SCUParkLckReq
20260605_AS5PR EV增补.xlsx_SCUParkLckReqEPMCU
20260605_AS5PR EV增补.xlsx_SCUParkLckReqV
20260605_AS5PR EV增补.xlsx_SCUParkLckReqVEPMCU
20260605_AS5PR EV增补.xlsx_SCUShiftrLvrPosn
20260605_AS5PR EV增补.xlsx_SCUShiftrLvrPosnLtchActv
20260605_AS5PR EV增补.xlsx_SCUShiftrLvrRawPosn
20260605_AS5PR EV增补.xlsx_SCUShiftrOpngRmndr
20260605_AS5PR EV增补.xlsx_SCUShiftrPosnInvsn
20260605_AS5PR EV增补.xlsx_SecuKeyVldSts
20260720_C1.xlsx_KeyAuthResp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group01/LHZCU_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>KeyAuthResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DigKeyAuthReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DigKeyPEValidReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqParkBtn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUAPAUnderCtrlActv</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUDrvMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUDrvrIntrvnActv</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUExtdShiftrFlr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUFltLvlWarn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUParkLckReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUParkLckReqEPMCU</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUParkLckReqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUParkLckReqVEPMCU</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShiftrLvrPosn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShiftrLvrPosnLtchActv</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShiftrLvrRawPosn</SHORT-LABEL>
                              <VALUE>0x2</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShiftrOpngRmndr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShiftrPosnInvsn</SHORT-LABEL>
                              <VALUE>0xF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SecuKeyVldSts</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9edd00">
                  <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251219_D5X EV 对比信号需求-2021219.xlsx_BrkLghtSwReq
20251219_D5X EV 对比信号需求-2021219.xlsx_DircnLghtOnReq_LHZCU
20251219_D5X EV 对比信号需求-2021219.xlsx_DrvrReqGearShftPos
20251219_D5X EV 对比信号需求-2021219.xlsx_DrvrReqGearShftPosInvs
20251219_D5X EV 对比信号需求-2021219.xlsx_EleccTrRngReq
20251219_D5X EV 对比信号需求-2021219.xlsx_LDayTimeRunningLghtCtrl
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_CRC
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_RC
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved1
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved2
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved3
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved4
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved5
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved6
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved7
20251219_D5X EV 对比信号需求-2021219.xlsx_LHZCU_10ms_Group32_Reserved8
20251219_D5X EV 对比信号需求-2021219.xlsx_MainBeamLghtSwReq
20251219_D5X EV 对比信号需求-2021219.xlsx_RDayTimeRunningLghtCtrl
20251219_D5X EV 对比信号需求-2021219.xlsx_RrFogLightOnReq
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUActrMvmntSts
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUDrvnIntrvnPos
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUExtdShifterActrPos
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUParkActrSts
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUShftLvrPosIncnstntFlag
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUShftLvrPosTrgt
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUTapUpDwnSwSta
20251219_D5X EV 对比信号需求-2021219.xlsx_SCUTapUpDwnSwStaInvsn
20251219_D5X EV 对比信号需求-2021219.xlsx_SideLghtOnReq
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DircnLghtOnReq_LHZCU
20260706_modify.xlsx_DircnLghtOnReq_LHZCU</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group32/LHZCU_10ms_Group32</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_10ms_Group32</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqGearShftPos</SHORT-LABEL>
                              <VALUE>0x8</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqGearShftPosInvs</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EleccTrRngReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUActrMvmntSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUDrvnIntrvnPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUExtdShifterActrPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUParkActrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShftLvrPosIncnstntFlag</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUShftLvrPosTrgt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUTapUpDwnSwSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUTapUpDwnSwStaInvsn</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDayTimeRunningLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MainBeamLghtSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDayTimeRunningLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrFogLightOnReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SideLghtOnReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnLghtOnReq_LHZCU</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SmrtKey4LoctnResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SmrtKeyLoctnFlrRsn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SmrtKeyLoctnProc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCUWKSTS</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved2</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved4</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_10ms_Group32_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb48f200">
                  <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250521_梳理--IP5PM EP信号需求V1.xlsx_HzrdLghtSwReq
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_BrkLghtCtrl
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_FLDircnLghtCtrl
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_FRDircnLghtCtrl
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_HzrdLghtSwReq
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_CRC
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_RC
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved1
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved2
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved3
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved4
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved5
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_LHZCU_20ms_Group03_Reserved6
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RevsLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_BrkLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_FLDircnLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_FRDircnLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_HzrdLghtSwReq
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_CRC
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_RC
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved1
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved2
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved3
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved4
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved5
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved6
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LHZCU_20ms_Group03_Reserved7
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_LMainBeamLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_RMainBeamLghtCtrl
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_RevsLghtCtrl
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_HzrdLghtSwReq
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PriySSBA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_PriySSBAV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkLghtCtrl
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RevsLghtCtrl
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RLDircnLghtCtrl
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RRDircnLghtCtrl</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_20ms_Group03/LHZCU_20ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_20ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FLDircnLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRDircnLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HzrdLghtSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LMainBeamLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RevsLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RMainBeamLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PriySSBA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PriySSBAV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SSBTrigd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SecySSBA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SecySSBAV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDircnLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDircnLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DippedBeamActStatus</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved5</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_20ms_Group03_Reserved6</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f7d0600db30fa900">
                  <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260720_C1.xlsx_LHZCU_400ms_Group18_CRC
20260720_C1.xlsx_LHZCU_400ms_Group18_RC
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved1
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved2
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved3
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved4
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved5
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved6
20260720_C1.xlsx_LHZCU_400ms_Group18_Reserved7
20260720_C1.xlsx_TPMSF
20260720_C1.xlsx_TPMSTirePrsLowIO</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_400ms_Group18/LHZCU_400ms_Group18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_400ms_Group18</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TPMSF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TPMSTirePrsLowIO</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_400ms_Group18_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_400ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb494000">
                  <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求V1-输出.xlsx_BntOpenSts
20250522_IP5PM EP信号需求V1-输出.xlsx_DrvrDetSts
20250522_IP5PM EP信号需求V1-输出.xlsx_DrvrDoorOpenSts
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_CRC
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_RC
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved1
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved2
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved3
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved4
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved5
20250522_IP5PM EP信号需求V1-输出.xlsx_LHZCU_50ms_Group06_Reserved6
20250522_IP5PM EP信号需求V1-输出.xlsx_RLDoorOpenSts
20250522_IP5PM EP信号需求V1-输出.xlsx_VehLckSts
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehLckSts
20251114_EP--AS5PR_EV高阶_20251107.xlsx_DrvrDoorOpenSts
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RLDoorOpenSts
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehLckSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BntOpenSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrDoorOpenSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RLDoorOpenSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehLckSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DirnLghtSftyMonErr
20260228_20260226-新增信号需求.xlsx_DrvrDetSts
20260228_20260226-新增信号需求.xlsx_DrvrDoorOpenSts
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehLckSts
20260528_新增接收.xlsx_VehLckSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group06/LHZCU_50ms_Group06</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_50ms_Group06</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BntOpenSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrDetSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrDoorOpenSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDoorOpenSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehLckSts</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DirnLghtSftyMonErr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLSInitnFltPrst</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved4</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved6</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved7</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group06_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba53200">
                  <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260226_20260226-新增信号需求.xlsx_DircnLghtFltsts
20260226_20260226-新增信号需求.xlsx_DircnLghtSts
20260226_20260226-新增信号需求.xlsx_DircnLghtSwReq
20260226_20260226-新增信号需求.xlsx_VehHzrdMdSts
20260703_modify.xlsx_DircnLghtFltsts
20260703_modify.xlsx_HUDLkngAmbtLghtLvlByLux
20260706_modify.xlsx_VehHzrdMdSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group24/LHZCU_50ms_Group24</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>LHZCU_50ms_Group24</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLSideLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRSideLghtCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtFltSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnLghtMdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DircnLghtSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HUDLkngAmbtLghtLvlByLux</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehHzrdMdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehIlluminateCtrlCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSideLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved31</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved39</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved47</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved55</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved49</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved60</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved79</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved87</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved81</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved111</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved121</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved135</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved143</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved151</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LHZCU_50ms_Group24_Reserved159</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb83d200">
                  <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MONSAMTqReq_Nm/MONSAMTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MONSAMTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb83f900">
                  <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MONTMTqReq_Nm/MONTMTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MONTMTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONTMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb278b00">
                  <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241118_副本总表_0.3_20241118.xlsx
20241128_副本总表_0.5_20241127.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MainBeamLghtOn/MainBeamLghtOn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MainBeamLghtOn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaa8700">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx
20260528_新增接收2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemPkngSlntPtrlEnbSwReq/MemPkngSlntPtrlEnbSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MemPkngSlntPtrlEnbSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSlntPtrlEnbSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaa6100">
                  <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx
20260528_新增接收2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemPkngSwReq/MemPkngSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MemPkngSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb2370700">
                  <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MnvrngPntDistNav/MnvrngPntDistNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MnvrngPntDistNav</SHORT-LABEL>
                          <VALUE>0x3FF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntDistNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb239c300">
                  <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MnvrngPntTypNav/MnvrngPntTypNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>MnvrngPntTypNav</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntTypNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb655600">
                  <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAETCSetSwReq/NOAETCSetSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAETCSetSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb64ba00">
                  <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOALaneSetSwReq/NOALaneSetSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOALaneSetSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb64e100">
                  <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAQukChgSwReq/NOAQukChgSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAQukChgSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb649300">
                  <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAReportSetSwReq/NOAReportSetSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOAReportSetSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb652f00">
                  <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPCitySwReq/NOPCitySwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOPCitySwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb646c00">
                  <SHORT-NAME>NOPSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSwReq/NOPSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NOPSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb68b000">
                  <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssQuit/NarRoVslAssQuit</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarRoVslAssQuit</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssQuit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb670300">
                  <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssSwReq/NarRoVslAssSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarRoVslAssSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb666700">
                  <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstSwReq/NarwSpcAstSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NarwSpcAstSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb941b00">
                  <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCndSpdLmtVal/NavCndSpdLmtVal</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavCndSpdLmtVal</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCndSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb692500">
                  <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCrntRoadTyp/NavCrntRoadTyp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavCrntRoadTyp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCrntRoadTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb937f00">
                  <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCtryCode_ISO/NavCtryCode_ISO</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavCtryCode_ISO</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCtryCode_ISO</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb694c00">
                  <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavDistFromFrtEleccEye/NavDistFromFrtEleccEye</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavDistFromFrtEleccEye</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavDistFromFrtEleccEye</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb697300">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavItvalSpdDetnDistRetDist/NavItvalSpdDetnDistRetDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavItvalSpdDetnDistRetDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavItvalSpdDetnDistRetDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb699a00">
                  <SHORT-NAME>NavNewIconDist</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavNewIconDist/NavNewIconDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavNewIconDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNewIconDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb93f400">
                  <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavNextRampOffset/NavNextRampOffset</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavNextRampOffset</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNextRampOffset</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb69c100">
                  <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtTyp/NavSpdLmtTyp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavSpdLmtTyp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb93a600">
                  <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtVal/NavSpdLmtVal</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavSpdLmtVal</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb93cd00">
                  <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtValSts/NavSpdLmtValSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavSpdLmtValSts</SHORT-LABEL>
                          <VALUE>0x2</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb69e800">
                  <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtValUnit/NavSpdLmtValUnit</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavSpdLmtValUnit</SHORT-LABEL>
                          <VALUE>0x2</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValUnit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7be600">
                  <SHORT-NAME>NavSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSts/NavSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NavSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb29fb00">
                  <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSwReq/NonDirectDMSSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NonDirectDMSSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4d0e00">
                  <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NorthVelocityRTK/NorthVelocityRTK</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NorthVelocityRTK</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NorthVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb675100">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwReq/NrwroadBwdAssConfrmSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadBwdAssConfrmSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb672a00">
                  <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwReq/NrwroadBwdAssSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadBwdAssSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb668e00">
                  <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdCtlReq/NrwroadFwdCtlReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdCtlReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb66b500">
                  <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdReq/NrwroadFwdReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadFwdReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb66dc00">
                  <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadsltReq/NrwroadsltReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>NrwroadsltReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbb8100">
                  <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260601_修改2.xlsx
20260703_modify.xlsx
20260720_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OnBdChrgrOptAltPwr/OnBdChrgrOptAltPwr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>OnBdChrgrOptAltPwr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OnBdChrgrOptAltPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb61af00">
                  <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrVal/OtsdAirTemCrVal</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>OtsdAirTemCrVal</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb627200">
                  <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20251217_D5X EV 对比信号需求-2021217.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrValMsk/OtsdAirTemCrValMsk</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>OtsdAirTemCrValMsk</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValMsk</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb61d600">
                  <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrValV/OtsdAirTemCrValV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>OtsdAirTemCrValV</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb686200">
                  <SHORT-NAME>PEBSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSwReq/PEBSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PEBSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbaaf300">
                  <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx_PEUMotASpd
20260409_20260408-AS5PR EV-PPV-V1.0.xlsx_PEUMotASpdV
20260720_C1.xlsx_PEUMotAMdAch
20260720_C1.xlsx_PEUMotBMdAch</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEU_10ms_Group25/PEU_10ms_Group25</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PEU_10ms_Group25</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEU_10ms_Group25_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEU_10ms_Group25_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotADampTrqCmdd</SHORT-LABEL>
                              <VALUE>0x7fff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotASpd</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotASpdV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotASpdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotAToqAch</SHORT-LABEL>
                              <VALUE>0x7ff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotAToqAchV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBDampTrqCmdd</SHORT-LABEL>
                              <VALUE>0x7fff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBSpd</SHORT-LABEL>
                              <VALUE>0x7fff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBSpdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBSpdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBToqAch</SHORT-LABEL>
                              <VALUE>0x3ff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBToqAchV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ReAxleMaxAvlblWhlDrvTq</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ReAxleMaxAvlblWhlDrvTqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ReAxleMaxAvlblWhlRgtnTq</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ReAxleMaxAvlblWhlRgtnTqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEU_10ms_Group25_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEU_10ms_Group25_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotAMdAch</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEUMotBMdAch</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PEU_10ms_Group25_Reserved147</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEU_10ms_Group25</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9b5600">
                  <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx_DrvrReqFrtAxleWhlToq
20251204_RZCU需求.xlsx_DrvrReqFrtAxleWhlToqV
20251204_RZCU需求.xlsx_DrvrReqRrAxleWhlToq
20251204_RZCU需求.xlsx_DrvrReqRrAxleWhlToqV
20251204_RZCU需求.xlsx_FrtAxleActuWhlToq
20251204_RZCU需求.xlsx_FrtAxleActuWhlToqV
20251204_RZCU需求.xlsx_PICU_10ms_Group03_CRC
20251204_RZCU需求.xlsx_PICU_10ms_Group03_RC
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved1
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved2
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved3
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved4
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved5
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved6
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved7
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved8
20251204_RZCU需求.xlsx_PICU_10ms_Group03_Reserved9
20251204_RZCU需求.xlsx_PtHVCntarReq
20251204_RZCU需求.xlsx_RrAxleActuWhlToq
20251204_RZCU需求.xlsx_RrAxleActuWhlToqV
20251204_RZCU需求.xlsx_TotActuWhlToq
20251204_RZCU需求.xlsx_TotActuWhlToqV
20260706_modify.xlsx_TotActuWhlToq</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_10ms_Group03/PICU_10ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PICU_10ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqFrtAxleWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqFrtAxleWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqRrAxleWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqRrAxleWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtAxleActuWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtAxleActuWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PtHVCntarReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrAxleActuWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrAxleActuWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TotActuWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TotActuWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group03_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba1b400">
                  <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260105_EV.xlsx_CrkshftNonTrRegdCmddToq
20260105_EV.xlsx_EnComFlrRducdPwrCmdd
20260105_EV.xlsx_EnDclFuelCutOffAld
20260105_EV.xlsx_EnDclFuelCutOffReq
20260105_EV.xlsx_EnDclFuelCutOffSta
20260105_EV.xlsx_EnFuelCutA
20260105_EV.xlsx_EnFuelRcvrySpd
20260105_EV.xlsx_EnHybVehStaOvrd
20260105_EV.xlsx_EnIdleCtrlA
20260105_EV.xlsx_EnIdleCtrlSts
20260105_EV.xlsx_EnReqdStTyp
20260105_EV.xlsx_EnSynRdy
20260105_EV.xlsx_EnSysDsbld
20260105_EV.xlsx_HybEnSpdReqF
20260105_EV.xlsx_HybEnStSpOvrd
20260105_EV.xlsx_PICU_10ms_Group23_CRC
20260105_EV.xlsx_PICU_10ms_Group23_RC
20260105_EV.xlsx_PtACCA
20260105_EV.xlsx_RVSEnRunning
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnStCtrlA</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_10ms_Group23/PICU_10ms_Group23</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PICU_10ms_Group23</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group23_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group23_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CrkshftNonTrRegdCmddToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnFuelCutA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnFuelRcvrySpd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnSynRdy</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PtACCA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RVSEnRunning</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnComFlrRducdPwrCmdd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnDclFuelCutOffAld</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnDclFuelCutOffReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnDclFuelCutOffSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnHybVehStaOvrd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnIdleCtrlA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnIdleCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnReqdStTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnSysDsbld</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HybEnSpdReqF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HybEnStSpOvrd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnStCtrlA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_10ms_Group23_Reserved18</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9d4100">
                  <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_CstRgtnBrkLgtReq
20251210_D5X EV 对比信号需求.xlsx_CstRgtnBrkLgtReqV
20251210_D5X EV 对比信号需求.xlsx_HybAPAAvlbl
20251210_D5X EV 对比信号需求.xlsx_MaxAvlblTotWhlToq
20251210_D5X EV 对比信号需求.xlsx_MaxAvlblTotWhlToqV
20251210_D5X EV 对比信号需求.xlsx_MinAvlblTotWhlToq
20251210_D5X EV 对比信号需求.xlsx_MinAvlblTotWhlToqV
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_CRC
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_RC
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved1
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved2
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved3
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved4
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved5
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved6
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved7
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved8
20251210_D5X EV 对比信号需求.xlsx_PICU_20ms_Group11_Reserved9
20251210_D5X EV 对比信号需求.xlsx_RdundtHybCmddEnToqImmd
20251210_D5X EV 对比信号需求.xlsx_RdundtHybCmddEnToqPrdtd
20251210_D5X EV 对比信号需求.xlsx_RdundtHybCmddEnToqRespTyp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_20ms_Group11/PICU_20ms_Group11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PICU_20ms_Group11</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CstRgtnBrkLgtReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CstRgtnBrkLgtReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HybAPAAvlbl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MaxAvlblTotWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MaxAvlblTotWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MinAvlblTotWhlToq</SHORT-LABEL>
                              <VALUE>0x7530</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MinAvlblTotWhlToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RdundtHybCmddEnToqImmd</SHORT-LABEL>
                              <VALUE>0x6a0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RdundtHybCmddEnToqPrdtd</SHORT-LABEL>
                              <VALUE>0x6a0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RdundtHybCmddEnToqRespTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved3</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved5</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved6</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PICU_20ms_Group11_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb903100">
                  <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250929_D5X-博伟需求-路由.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_PTAvlbly/PICU_PTAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PICU_PTAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_PTAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb681400">
                  <SHORT-NAME>ParkngDirSw</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirSw/ParkngDirSw</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ParkngDirSw</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4daa00">
                  <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PositionAttitudeStatus/PositionAttitudeStatus</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PositionAttitudeStatus</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PositionAttitudeStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb842000">
                  <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PwrDMd_enum/PwrDMd_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PwrDMd_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrDMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb844700">
                  <SHORT-NAME>PwrReq_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PwrReq_flg/PwrReq_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>PwrReq_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb65f200">
                  <SHORT-NAME>RACtlReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RACtlReq/RACtlReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RACtlReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RACtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb635b00">
                  <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RCTSysSelReq/RCTSysSelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RCTSysSelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb63a900">
                  <SHORT-NAME>RCWSelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RCWSelReq/RCWSelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RCWSelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb62e600">
                  <SHORT-NAME>RDASwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RDASwReq/RDASwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RDASwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RDASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9c1900">
                  <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFCTWrnng_ADAS/RFCTWrnng_ADAS</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RFCTWrnng_ADAS</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9c6300">
                  <SHORT-NAME>RFSDA_20ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_AEBDclReqSts_ADAS
20251210_D5X EV 对比信号需求.xlsx_AEBDclReqToqVal_ADAS
20251210_D5X EV 对比信号需求.xlsx_AEBDclReqVal_ADAS</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFSDA_20ms_Group02/RFSDA_20ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RFSDA_20ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqSts_ADAS</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqToqVal_ADAS</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AEBDclReqVal_ADAS</SHORT-LABEL>
                              <VALUE>0x7F</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RFSDA_20ms_Group02_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFSDA_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba1db00">
                  <SHORT-NAME>RHRDA_50ms_Group04</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RDASysSta
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RLRdrEmgcLineChngWrnng
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RRRdrEmgcLineChngWrnng
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_RDASysSta
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_RLRdrEmgcLineChngWrnng
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_RRRdrEmgcLineChngWrnng
20260528_新增接收.xlsx_RLRdrEmgcLineChngWrnng
20260528_新增接收.xlsx_RRRdrEmgcLineChngWrnng
20260528_新增接收.xlsx_RDASysSta
20260706_modify.xlsx_BSDSelSts
20260706_modify.xlsx_LBSDAndLCAWrnng
20260706_modify.xlsx_LCASelSts
20260706_modify.xlsx_LDOWWrnng
20260706_modify.xlsx_LRCTAWrnng
20260706_modify.xlsx_RBSDAndLCAWrnng
20260706_modify.xlsx_RCTSysSelSts
20260706_modify.xlsx_RDASysSta
20260706_modify.xlsx_RDOWWrnng
20260706_modify.xlsx_RRCTAWrnng</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHRDA_50ms_Group04/RHRDA_50ms_Group04</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHRDA_50ms_Group04</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BSDSelSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DOWSelSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LBSDAndLCAWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LCASelSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDOWWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LRCTAWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RBSDAndLCAWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RCTSysSelSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDASwSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDASysSta</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDOWWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRCTAWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLRdrEmgcLineChngWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRRdrEmgcLineChngWrnng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrCrnRdrCalSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_Reserved3</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHRDA_50ms_Group04_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHRDA_50ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb905800">
                  <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250929_D5X-博伟需求-路由.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCUAvlbly/RHZCUAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHZCUAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbb3200">
                  <SHORT-NAME>RHZCU_100ms_Group10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260601_修改1.xlsx_ACAmbtTem
20260601_修改1.xlsx_ACAmbtTemMsk
20260601_修改1.xlsx_ACAmbtTemV
20260601_修改1.xlsx_ACComprActuPwr
20260601_修改1.xlsx_FRSeatHorzPos
20260601_修改1.xlsx_FRSeatVertPos
20260601_修改1.xlsx_RHZCU_100ms_Group10_CRC
20260601_修改1.xlsx_RHZCU_100ms_Group10_RC
20260601_修改1.xlsx_RHZCU_100ms_Group10_Reserved1
20260601_修改1.xlsx_RHZCU_100ms_Group10_Reserved2
20260601_修改1.xlsx_RHZCU_100ms_Group10_Reserved3
20260601_修改1.xlsx_RHZCU_100ms_Group10_Reserved4
20260601_修改1.xlsx_RHZCU_100ms_Group10_Reserved5
20260601_修改2.xlsx_FRSeatVertPos
20260706_modify.xlsx_ACAmbtTem
20260706_modify.xlsx_ACAmbtTemV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_100ms_Group10/RHZCU_100ms_Group10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHZCU_100ms_Group10</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACAmbtTem</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACAmbtTemMsk</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACAmbtTemV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ACComprActuPwr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRSeatHorzPos</SHORT-LABEL>
                              <VALUE>0xFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FRSeatVertPos</SHORT-LABEL>
                              <VALUE>0xFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_Reserved2</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_100ms_Group10_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8db600">
                  <SHORT-NAME>RHZCU_50ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250701_工作簿1.xlsx_FrtPsngDoorOpenSts
20250701_工作簿1.xlsx_RHZCU_50ms_Group01_CRC
20250701_工作簿1.xlsx_RHZCU_50ms_Group01_RC
20250701_工作簿1.xlsx_RHZCUeSw41DiagSts
20250701_工作簿1.xlsx_RHZCUeSw41Sts
20250701_工作簿1.xlsx_RRDoorOpenSts
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RRDoorOpenSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RRDoorOpenSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group01/RHZCU_50ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHZCU_50ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDoorOpenSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw41DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw41Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group01_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb48a400">
                  <SHORT-NAME>RHZCU_50ms_Group27</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250520_IP5PM EP信号需求--modify.xlsx_RHZCUeSw3Sts
20250520_IP5PM EP信号需求--modify.xlsx_RHZCUeSw9Sts
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RHZCUeSw9Sts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group27/RHZCU_50ms_Group27</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHZCU_50ms_Group27</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw37DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw37Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw3DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw3Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw9DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw9Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw33DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw33Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw42DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw42Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw43DiagSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCUeSw43Sts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved4</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved5</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved6</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RHZCU_50ms_Group27_Reserved7</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group27</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb479600">
                  <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250312_大众A车高配信号导出表_20250303.xlsx
20250520_IP5PM EP信号需求--modify.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCUeFs1Sts/RHZCUeFs1Sts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RHZCUeFs1Sts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUeFs1Sts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb989800">
                  <SHORT-NAME>RLTirePrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTirePrs/RLTirePrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLTirePrs</SHORT-LABEL>
                          <VALUE>0x37</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb98bf00">
                  <SHORT-NAME>RLTirePrsV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTirePrsV/RLTirePrsV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLTirePrsV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f498f2acb3576000">
                  <SHORT-NAME>RLTireSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260710_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireSts/RLTireSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLTireSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb990d00">
                  <SHORT-NAME>RLTireTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireTem/RLTireTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLTireTem</SHORT-LABEL>
                          <VALUE>0x2D</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb993400">
                  <SHORT-NAME>RLTireTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireTemV/RLTireTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RLTireTemV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb995b00">
                  <SHORT-NAME>RRTirePrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTirePrs/RRTirePrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRTirePrs</SHORT-LABEL>
                          <VALUE>0x37</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb998200">
                  <SHORT-NAME>RRTirePrsV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTirePrsV/RRTirePrsV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRTirePrsV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f498f2acb35b7a00">
                  <SHORT-NAME>RRTireSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260710_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireSts/RRTireSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRTireSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb99d000">
                  <SHORT-NAME>RRTireTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireTem/RRTireTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRTireTem</SHORT-LABEL>
                          <VALUE>0x2D</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb99f700">
                  <SHORT-NAME>RRTireTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireTemV/RRTireTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RRTireTemV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb622400">
                  <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCUIgnDiagSts/RZCUIgnDiagSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCUIgnDiagSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnDiagSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb624b00">
                  <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCUIgnSts/RZCUIgnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCUIgnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba57f00">
                  <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EleccLckCtrlResp
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_FlbStrgFnSts
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_FlbStrgFnStsResp
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_IMU_Signal_status
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OfbdChrgrNgtvSktTem
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OfbdChrgrNgtvSktTemV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OnBdChrgrSktElecLckSta
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OnBdChrgrSktElecLckStaV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OnBdChrgrSktPstvSnsrTem
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OnBdChrgrSktPstvSnsrTemV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OnbdChrgrSktEleccLckEnable
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_100ms_Group10_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_100ms_Group10_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VCUCtrlS2Req
20260708_modify.xlsx_OnbdChrgrSktEleccLckEnable</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_100ms_Group10/RZCU_100ms_Group10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_100ms_Group10</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMU_Signal_status</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VCUCtrlS2Req</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EleccLckCtrlResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FlbStrgFnSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FlbStrgFnStsResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OfbdChrgrNgtvSktTem</SHORT-LABEL>
                              <VALUE>0xFE</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OfbdChrgrNgtvSktTemV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrSktElecLckSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrSktElecLckStaV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrSktPstvSnsrTem</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrSktPstvSnsrTemV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrSktEleccLckEnable</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_Reserved3</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_Reserved4</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_100ms_Group10_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9d6800">
                  <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_AutoChrgngMngmnt
20251210_D5X EV 对比信号需求.xlsx_EPTAccelActuPos
20251210_D5X EV 对比信号需求.xlsx_EPTAccelActuPosV
20251210_D5X EV 对比信号需求.xlsx_EPTAccelEfctvPos
20251210_D5X EV 对比信号需求.xlsx_EPTBrkPdlDscrtInptSts
20251210_D5X EV 对比信号需求.xlsx_EPTBrkPdlDscrtInptStsV
20251210_D5X EV 对比信号需求.xlsx_EPTCrkAbotd
20251210_D5X EV 对比信号需求.xlsx_EPTHVDCDCMdReq
20251210_D5X EV 对比信号需求.xlsx_EPTHVEmgcPwrOffReq
20251210_D5X EV 对比信号需求.xlsx_EPTMainRelayDrvReq
20251210_D5X EV 对比信号需求.xlsx_EPTStCmdOn
20251210_D5X EV 对比信号需求.xlsx_ElecMotEmgcShutDwn
20251210_D5X EV 对比信号需求.xlsx_RVSEPTRdy
20251210_D5X EV 对比信号需求.xlsx_RZCU_10ms_Group01_CRC
20251210_D5X EV 对比信号需求.xlsx_RZCU_10ms_Group01_RC
20251210_D5X EV 对比信号需求.xlsx_RZCU_10ms_Group01_Reserved1
20251210_D5X EV 对比信号需求.xlsx_RZCU_10ms_Group01_Reserved2
20251210_D5X EV 对比信号需求.xlsx_RZCU_10ms_Group01_Reserved3
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_EPTStCmdOn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTAccelActuPos
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTAccelActuPosV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTAccelEfctvPos
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTBrkPdlDscrtInptSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTBrkPdlDscrtInptStsV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTStCmdOn
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_AutoChrgngMngmnt
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTAccelActuPos
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTAccelActuPosV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTAccelEfctvPos
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTBrkPdlDscrtInptSts
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTBrkPdlDscrtInptStsV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTCrkAbotd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTHVDCDCMdReq
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTHVEmgcPwrOffReq
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTMainRelayDrvReq
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTStCmdOn
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ElecMotEmgcShutDwn
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RVSEPTRdy
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_10ms_Group01_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_10ms_Group01_RC
20260706_modify.xlsx_EPTAccelActuPos
20260706_modify.xlsx_EPTBrkPdlDscrtInptSts
20260708_modify.xlsx_EPTStCmdOn</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group01/RZCU_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTAccelActuPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTAccelActuPosV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTAccelEfctvPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTBrkPdlDscrtInptSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTBrkPdlDscrtInptStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTCrkAbotd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTStCmdOn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTHVDCDCMdReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RVSEPTRdy</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoChrgngMngmnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTHVEmgcPwrOffReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTMainRelayDrvReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ElecMotEmgcShutDwn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7bbf00">
                  <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_EPTTrInptShaftSpd
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_EPTTrInptShaftSpdV
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group02_CRC
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group02_RC
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group02_Reserved1
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group02_Reserved2
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group02_Reserved3
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTSecyAxleInptShaftSpd
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTSecyAxleInptShaftSpdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTSecyAxleInptShaftSpd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTSecyAxleInptShaftSpdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTTrInptShaftSpd
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTTrInptShaftSpdV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTTrInptShaftSpdV_R
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTTrInptShaftSpd_R
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RZCU_10ms_Group02_CRC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RZCU_10ms_Group02_RC
20260703_modify.xlsx_EPTTrInptShaftSpd_R</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group02/RZCU_10ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrInptShaftSpd</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrInptShaftSpdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTSecyAxleInptShaftSpd</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTSecyAxleInptShaftSpdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrInptShaftSpd_R</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrInptShaftSpdV_R</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7c8200">
                  <SHORT-NAME>RZCU_10ms_Group22</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotMaxAvlblToq
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotMaxAvlblToqV
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotMinAvlblToq
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotMinAvlblToqV
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotToq
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_EPTTrOtptShaftTotToqV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VMCTarReWhlTqMaxLmt
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VMCTarWhlTqMaxLmt
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VMCTarWhlTqMaxLmtV
20260706_modify.xlsx_EPTTrOtptShaftTotToq</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group22/RZCU_10ms_Group22</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group22</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotMaxAvlblToq</SHORT-LABEL>
                              <VALUE>0x6A0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotMaxAvlblToqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotMinAvlblToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotMinAvlblToqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTTrOtptShaftTotToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group22_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group22_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VMCTarReWhlTqMaxLmt</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VMCTarWhlTqMaxLmt</SHORT-LABEL>
                              <VALUE>0x7FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VMCTarWhlTqMaxLmtV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VMCTarReWhlTqMaxLmtV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group22_Reserved47</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group22_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group22</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7b7100">
                  <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_AccelOvrd
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_PtACCToqReqResp
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group23_CRC
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group23_RC
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_AIPilotSysSaBrInh
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_AIPilotSysSaBrSts
20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx_AutodDrvngToqReqResp
20251210_D5X EV 对比信号需求.xlsx_PtAPAToqReqResp
20251211_D5X EV 对比信号需求.xlsx_PtAPAToqReqResp
20260706_modify.xlsx_AccelOvrd
20260706_modify.xlsx_PtACCToqReqResp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group23/RZCU_10ms_Group23</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group23</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelOvrd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PtACCToqReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AIPilotSysSaBrInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AIPilotSysSaBrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutodDrvngToqReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PtAPAToqReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved2</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved3</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved4</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved6</SHORT-LABEL>
                              <VALUE>0x7f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved14</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group23_Reserved15</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7b9800">
                  <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_EPTAPARevrDrgReqResp
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_CRC
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_RC
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved1
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved2
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved3
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved4
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved5
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_RZCU_10ms_Group24_Reserved6
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VCUAPAFltRsn
20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VCUAPAUnderCtrlA</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group24/RZCU_10ms_Group24</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group24</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTAPARevrDrgReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VCUAPAFltRsn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VCUAPAUnderCtrlA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PtAPASts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group24_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb27e00">
                  <SHORT-NAME>RZCU_10ms_Group90</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260528_AS5PMCAN需求导入表.xlsx_VCU_ISAOvSpdOvRd
20260707_modify.xlsx_VCU_ISAOvSpdOvRd</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group90/RZCU_10ms_Group90</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_10ms_Group90</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VCU_ISAOvSpdOvRd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved31</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved39</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved47</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved79</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved87</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved83</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved135</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved143</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved151</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved159</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_10ms_Group90_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group90</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9d8f00">
                  <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_EPTRdy
20251210_D5X EV 对比信号需求.xlsx_EPTRdyV
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_CRC
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_RC
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_Reserved1
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_Reserved2
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_Reserved3
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_Reserved4
20251210_D5X EV 对比信号需求.xlsx_RZCU_20ms_Group06_Reserved5
20251210_D5X EV 对比信号需求.xlsx_TrEngdSta
20251210_D5X EV 对比信号需求.xlsx_TrEngdStaV
20251210_D5X EV 对比信号需求.xlsx_TrEstdGear
20251210_D5X EV 对比信号需求.xlsx_TrEstdGearV
20251210_D5X EV 对比信号需求.xlsx_TrShftLvrPos
20251210_D5X EV 对比信号需求.xlsx_TrShftLvrPosV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_EPTRdy
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_EPTRdyV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_TrShftLvrPos
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_TrShftLvrPosV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTRdy
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTRdyV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RZCU_20ms_Group06_CRC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RZCU_20ms_Group06_RC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrEngdSta
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrEngdStaV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrEstdGear
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrEstdGearV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPos
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPosV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTRdy
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPTRdyV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrEstdGear
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPos
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPosV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTRdy
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EPTRdyV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_20ms_Group06_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_RZCU_20ms_Group06_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrEngdSta
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrEngdStaV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrEstdGear
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrEstdGearV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrShftLvrPos
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrShftLvrPosV
20260703_modify.xlsx_TrEstdGearV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_20ms_Group06/RZCU_20ms_Group06</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_20ms_Group06</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTRdy</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEstdGearV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEstdGear</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrShftLvrPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrShftLvrPosV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEngdSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEngdStaV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPTRdyV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_Reserved1</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_20ms_Group06_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_20ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba0f600">
                  <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_BrkLghtFltSts_HW
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_BrkLghtSts_HW
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_ChrgrFlapLtchCtrl
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_LdspcOpenSts
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_LdspcOpenStsV
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_PwrLftgtClsSwtActv
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_RLDircnLghtFltsts
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_RLDircnLghtSts
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_RRDircnLghtFltsts
20251217_EP-12-20251216_AS5PR_EV高配阶段性导出.xlsx_RRDircnLghtSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_LdspcOpenSts
20260706_modify.xlsx_LdspcOpenSts
20260706_modify.xlsx_LdspcOpenStsV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_50ms_Group37/RZCU_50ms_Group37</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_50ms_Group37</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtFltSts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtSts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChrgrFlapLtchCtrl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LdspcOpenSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LdspcOpenStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PwrLftgtClsSwtActv</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDircnLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDircnLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDircnLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDircnLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RearFogLghtFltsts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RearFogLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RevsLghtFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RevsLghtSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDircnLghtFltsts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RLDircnLghtSts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDircnLghtFltsts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RRDircnLghtSts_HW</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved23</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved31</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved38</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved36</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved34</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_50ms_Group37_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_50ms_Group37</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8b9500">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_MG6 PHEVEV 高配 有效性信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_BKBCANFDAvlbly/RZCU_BKBCANFDAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_BKBCANFDAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_BKBCANFDAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8e2b00">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250703_工作簿2-20250703.xlsx_AccelerationXsecinfo
20250703_工作簿2-20250703.xlsx_AccelerationXsecinfoV
20250703_工作簿2-20250703.xlsx_AccelerationYsecinfo
20250703_工作簿2-20250703.xlsx_AccelerationYsecinfoV
20250703_工作簿2-20250703.xlsx_AccelerationZsecinfo
20250703_工作簿2-20250703.xlsx_AccelerationZsecinfoV
20250703_工作簿2-20250703.xlsx_AngularRateXsecinfo
20250703_工作簿2-20250703.xlsx_AngularRateXsecinfoV
20250703_工作簿2-20250703.xlsx_AngularRateYsecinfo
20250703_工作簿2-20250703.xlsx_AngularRateYsecinfoV
20250703_工作簿2-20250703.xlsx_AngularRateZsecinfo
20250703_工作簿2-20250703.xlsx_AngularRateZsecinfoV
20250703_工作簿2-20250703.xlsx_IMUTmp
20250703_工作簿2-20250703.xlsx_IMUseq
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_TireBlowoutPos
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_TireBlowoutStabCtrlSts
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RZCU_ZONE_10ms_Group64_CRC
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RZCU_ZONE_10ms_Group64_RC</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RZCU_ZONE_10ms_Group64</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationXsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationXsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationYsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationYsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationZsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AccelerationZsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateXsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateXsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateYsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateYsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateZsecinfo</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AngularRateZsecinfoV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMUTmp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IMUseq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TireBlowoutPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TireBlowoutStabCtrlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RZCU_ZONE_10ms_Group64_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_ZONE_10ms_Group64</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5ef900">
                  <SHORT-NAME>ResetCnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx
20260528_新增接收2.xlsx
20260703_modify.xlsx
20260706_modify.xlsx
20260707_modify.xlsx
20260715_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ResetCnt/ResetCnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ResetCnt</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ResetCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb846e00">
                  <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Rolloff2Min_flg/Rolloff2Min_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Rolloff2Min_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Rolloff2Min_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb849500">
                  <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RolloffHld_flg/RolloffHld_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RolloffHld_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RolloffHld_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9a1e00">
                  <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrTireStdPrs/RrTireStdPrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RrTireStdPrs</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2a2200">
                  <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250207_ANB智驾L2+信号需求_20241127.xlsx
20250523_IP5PM EP信号需求V2-热管理-输出--梳理1.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RstrFctryDeftsReq/RstrFctryDeftsReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>RstrFctryDeftsReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RstrFctryDeftsReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8b6e00">
                  <SHORT-NAME>SDMAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_MG6 PHEVEV 高配 有效性信号需求.xlsx
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDMAvlbly/SDMAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SDMAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8e5200">
                  <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250703_工作簿2-20250703.xlsx_AirbagDplForeCall
20250703_工作簿2-20250703.xlsx_AirbagDplInvsneForeCall
20250703_工作簿2-20250703.xlsx_AirbagSysFltForeCall
20250703_工作簿2-20250703.xlsx_DrvrSbltAtc
20250703_工作簿2-20250703.xlsx_DrvrSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnDrvrSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnFrtPsngSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnSbltAudRmndr
20250703_工作簿2-20250703.xlsx_FasnSecRowLSbltAtc
20250703_工作簿2-20250703.xlsx_FasnSecRowLSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnSecRowLSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnSecRowMidSbltAtc
20250703_工作簿2-20250703.xlsx_FasnSecRowMidSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnSecRowMidSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnSecRowRSbltAtc
20250703_工作簿2-20250703.xlsx_FasnSecRowRSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnSecRowRSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnThrdRowLSbltAtc
20250703_工作簿2-20250703.xlsx_FasnThrdRowLSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnThrdRowLSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnThrdRowMidSbltAtc
20250703_工作簿2-20250703.xlsx_FasnThrdRowMidSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnThrdRowMidSbltIndCmd
20250703_工作簿2-20250703.xlsx_FasnThrdRowRSbltAtc
20250703_工作簿2-20250703.xlsx_FasnThrdRowRSbltAtcV
20250703_工作簿2-20250703.xlsx_FasnThrdRowRSbltIndCmd
20250703_工作簿2-20250703.xlsx_FrtPsngSbltAtc
20250703_工作簿2-20250703.xlsx_FrtPsngSbltAtcV
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_CRC
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_RC
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_Reserved1
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_Reserved2
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_Reserved3
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group01_Reserved4
20251114_EP--AS5PR_EV高阶_20251107.xlsx_DrvrSbltAtc
20251114_EP--AS5PR_EV高阶_20251107.xlsx_DrvrSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnDrvrSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnFrtPsngSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSbltAudRmndr
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowLSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowLSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowLSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowMidSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowMidSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowMidSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowRSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowRSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnSecRowRSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowLSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowLSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowLSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowMidSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowMidSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowMidSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowRSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowRSbltAtcV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FasnThrdRowRSbltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngSbltAtc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngSbltAtcV
20260228_20260226-新增信号需求.xlsx_DrvrSbltAtc
20260228_20260226-新增信号需求.xlsx_DrvrSbltAtcV
20260228_20260226-新增信号需求.xlsx_FrtPsngSbltAtc
20260228_20260226-新增信号需求.xlsx_FrtPsngSbltAtcV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group01/SDM_20ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SDM_20ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagDplForeCall</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagDplInvsneForeCall</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagSysFltForeCall</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnDrvrSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnFrtPsngSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSbltAudRmndr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowLSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowLSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowLSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowMidSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowMidSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowMidSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowRSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowRSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnSecRowRSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowLSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowLSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowLSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowMidSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowMidSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowMidSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowRSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowRSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnThrdRowRSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnDrvrSbltIndCmdEvtTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8e0400">
                  <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250703_工作簿2-20250703.xlsx_AirbagDpl
20250703_工作簿2-20250703.xlsx_AirbagDplInvsn
20250703_工作簿2-20250703.xlsx_AirbagSysFlt
20250703_工作簿2-20250703.xlsx_AirbagSysFltIndCmd
20250703_工作簿2-20250703.xlsx_FrtPsngAirbagDsblIndF
20250703_工作簿2-20250703.xlsx_FrtPsngAirbagEnbIndF
20250703_工作簿2-20250703.xlsx_FrtPsngAirbagIndReq
20250703_工作簿2-20250703.xlsx_FrtPsngAirbagSwSts
20250703_工作簿2-20250703.xlsx_PedtrnProtnSysDplSts
20250703_工作簿2-20250703.xlsx_PedtrnProtnSysDplStsV
20250703_工作簿2-20250703.xlsx_PedtrnProtnSysIndrCmd
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_CRC
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_RC
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved1
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved2
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved3
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved4
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved5
20250703_工作簿2-20250703.xlsx_SDM_20ms_Group02_Reserved6
20250703_工作簿2-20250703.xlsx_VehCrshTyp
20250714_工作簿3-20250710.xlsx_AirbagDpl
20250714_工作簿3-20250710.xlsx_AirbagDplInvsn
20250714_工作簿3-20250710.xlsx_AirbagSysFlt
20250714_工作簿3-20250710.xlsx_AirbagSysFltIndCmd
20250714_工作簿3-20250710.xlsx_FrtPsngAirbagDsblIndF
20250714_工作簿3-20250710.xlsx_FrtPsngAirbagEnbIndF
20250714_工作簿3-20250710.xlsx_FrtPsngAirbagIndReq
20250714_工作簿3-20250710.xlsx_FrtPsngAirbagSwSts
20250714_工作簿3-20250710.xlsx_PedtrnProtnSysDplSts
20250714_工作簿3-20250710.xlsx_PedtrnProtnSysDplStsV
20250714_工作簿3-20250710.xlsx_PedtrnProtnSysIndrCmd
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_CRC
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_RC
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved1
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved2
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved3
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved4
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved5
20250714_工作簿3-20250710.xlsx_SDM_20ms_Group02_Reserved6
20250714_工作簿3-20250710.xlsx_VehCrshTyp
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_AirbagDpl
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_AirbagDplInvsn
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_AirbagDpl
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_AirbagDplInvsn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AirbagDpl
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AirbagDplInvsn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AirbagSysFlt
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AirbagSysFltIndCmd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngAirbagDsblIndF
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngAirbagEnbIndF
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngAirbagIndReq
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_FrtPsngAirbagSwSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehCrshTyp
20260703_modify.xlsx_VehCrshTyp
20260706_modify.xlsx_AirbagDpl
20260706_modify.xlsx_AirbagDplInvsn</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group02/SDM_20ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SDM_20ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagDsblIndF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagEnbIndF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagIndReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FrtPsngAirbagSwSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PedtrnProtnSysDplSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PedtrnProtnSysDplStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PedtrnProtnSysIndrCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehCrshTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagDpl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagDplInvsn</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagSysFlt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirbagSysFltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FMOccupntSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnFrtRowMidSbltAtc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnFrtRowMidSbltAtcV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FasnFrtRowMidSbltIndCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved16</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved31</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved37</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved47</SHORT-LABEL>
