                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X137</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X138</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X139</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X140</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X141</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X142</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X143</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X144</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU16/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f49da00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs12Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c1100">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw40Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e4800">
                  <SHORT-NAME>X140</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWlcmReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e2d00">
                  <SHORT-NAME>X139</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFllwMeReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c4700">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a4600">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs8Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b3900">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw24Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4ae800">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw17Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>76</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4acd00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw16Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4ab200">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw15Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a9700">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw14Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>97</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a7c00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw13Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>104</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a6100">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw12Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b5400">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw26Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>128</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a2b00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs6Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>148</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4bc000">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw32Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>155</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4a1000">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs4Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>162</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b6f00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw27Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>168</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f49bf00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUBkupInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b0300">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw1Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>199</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b1e00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw20Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>206</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4bf600">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw3Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>213</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4b8a00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw29Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>216</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4bdb00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw36Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>239</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f49f500">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs13Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>240</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4ba500">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw30Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>263</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4da600">
                  <SHORT-NAME>X137</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw31Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>264</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d5500">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrwlLghtReq_LHZCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>267</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c2c00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw43Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>287</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f49a300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUAddtnInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>303</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c7d00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw44Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>311</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c9800">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw45Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>318</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e6300">
                  <SHORT-NAME>X141</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatZeroSt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>321</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4cb300">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw46Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>335</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4cce00">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw47Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>336</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4dc100">
                  <SHORT-NAME>X138</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWlcmLghtReq_LHZCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>338</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d0400">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDoorOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>341</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4df700">
                  <SHORT-NAME>HUDLghtSnsrHdwrFltPrst</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDLghtSnsrHdwrFltPrst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>342</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4eb400">
                  <SHORT-NAME>X144</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatRclnMotActn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>362</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e9900">
                  <SHORT-NAME>X143</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVertMotActn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>364</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e7e00">
                  <SHORT-NAME>X142</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHoztMotActn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>366</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4ddc00">
                  <SHORT-NAME>HUDFwdLkngAmbtLghtLvl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDFwdLkngAmbtLghtLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>383</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d1f00">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFollowMeHomeReq_LHZCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>384</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4ce900">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBklghtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>385</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4e1200">
                  <SHORT-NAME>HUDRLSAmbtLghtLvl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDRLSAmbtLghtLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>399</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4c6200">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs15Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>400</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d7000">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHmdtySnsrHdwrFltPrst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>401</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d3a00">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngDoorOpenSts_LHZCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>403</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4991xOa505a3f19f25843c4b2f4d8b00">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs17Crnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>423</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f4ee5XOa505a3f19f25843c4b2f4ee400">
              <SHORT-NAME>LHZCU_100ms_PDU22</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/FrtWiperOpReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU22/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f6400">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILowBttySta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>8</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f7f00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPutSmrtKeyToBkupPosRmnr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>9</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f9a00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITakeKeyOutRmndr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>10</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f4900">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICustrDblCnfmGearShftReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4ef700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWiperSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f1300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWshrPumpA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4ee5xOa505a3f19f25843c4b2f4f2e00">
                  <SHORT-NAME>FrtWiperOpReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWiperOpReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b31f38cXOa505a3f19f25843c4b31f38b00">
              <SHORT-NAME>LHZCU_100ms_PDU30</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_100ms_PDU30/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f3cd00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f3e800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f43900">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved12</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f41e00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLampSwStsMntry</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f45400">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved23</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f46f00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved31</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f3b200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHorzPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f40300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVertPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f48a00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved55</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f4a500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f4c000">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved71</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f4db00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved79</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f4f600">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved87</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f51100">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved95</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f52c00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved103</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f54700">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved111</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f56200">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved119</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f57d00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved127</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31f38cxOa505a3f19f25843c4b31f39e00">
                  <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_100ms_Group30</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f4fcaXOa505a3f19f25843c4b2f4fc900">
              <SHORT-NAME>LHZCU_10ms_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU01/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f505900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f507300">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f50f500">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUFltLvlWarn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f50a700">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f50db00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUExtdShiftrFlr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f51c500">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrOpngRmndr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f503f00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeyAuthResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f510f00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f514300">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f521300">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f4fde00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyAuthReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f51ab00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrRawPosn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f515d00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqVEPMCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f522d00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f512900">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqEPMCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f51df00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrPosnInvsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f517700">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrPosn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f502500">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqParkBtn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f519100">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrPosnLtchActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f51f900">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecuKeyVldSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f50c100">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvrIntrvnActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f508d00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUAPAUnderCtrlActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f500b00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyPEValidReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f4fcaxOa505a3f19f25843c4b2f4ff800">
                  <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_10ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f6865XOa505a3f19f25843c4b2f686400">
              <SHORT-NAME>LHZCU_10ms_PDU32</SHORT-NAME>
              <LENGTH>12</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/BrkLghtSwReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/DircnLghtOnReq_LHZCU</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/DrvrReqGearShftPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/DrvrReqGearShftPosInvs</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/EleccTrRngReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/LDayTimeRunningLghtCtrl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/LHZCU_10ms_Group32_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/LHZCU_10ms_Group32_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/MainBeamLghtSwReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/RDayTimeRunningLghtCtrl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/RrFogLightOnReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUActrMvmntSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUDrvnIntrvnPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUExtdShifterActrPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUParkActrSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUShftLvrPosIncnstntFlag</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUShftLvrPosTrgt</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUTapUpDwnSwSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SCUTapUpDwnSwStaInvsn</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SideLghtOnReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SmrtKey4LoctnResp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SmrtKeyLoctnFlrRsn</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/SmrtKeyLoctnProc</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_10ms_PDU32/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f692800">
                  <SHORT-NAME>LHZCU_10ms_Group32_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f694200">
                  <SHORT-NAME>LHZCU_10ms_Group32_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6afc00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f687900">
                  <SHORT-NAME>BrkLghtSwReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f690e00">
                  <SHORT-NAME>SideLghtOnReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISideLghtOnReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f68c000">
                  <SHORT-NAME>MainBeamLghtSwReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b1600">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f695c00">
                  <SHORT-NAME>DrvrReqGearShftPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b3000">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f68f400">
                  <SHORT-NAME>RrFogLightOnReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLightOnReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f68da00">
                  <SHORT-NAME>RDayTimeRunningLghtCtrl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDayTimeRunningLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f68a600">
                  <SHORT-NAME>LDayTimeRunningLghtCtrl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDayTimeRunningLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f699000">
                  <SHORT-NAME>EleccTrRngReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEleccTrRngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f697600">
                  <SHORT-NAME>DrvrReqGearShftPosInvs</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPosInvs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a7a00">
                  <SHORT-NAME>DircnLghtOnReq_LHZCU</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtOnReq_LHZCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f69c400">
                  <SHORT-NAME>SCUDrvnIntrvnPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvnIntrvnPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b4a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a1200">
                  <SHORT-NAME>SCUShftLvrPosIncnstntFlag</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShftLvrPosIncnstntFlag</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a2c00">
                  <SHORT-NAME>SCUShftLvrPosTrgt</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShftLvrPosTrgt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f69de00">
                  <SHORT-NAME>SCUExtdShifterActrPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUExtdShifterActrPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a6000">
                  <SHORT-NAME>SCUTapUpDwnSwStaInvsn</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUTapUpDwnSwStaInvsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a4600">
                  <SHORT-NAME>SCUTapUpDwnSwSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUTapUpDwnSwSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f69f800">
                  <SHORT-NAME>SCUParkActrSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkActrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f69aa00">
                  <SHORT-NAME>SCUActrMvmntSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUActrMvmntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6a9400">
                  <SHORT-NAME>SmrtKey4LoctnResp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey4LoctnResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6ac800">
                  <SHORT-NAME>SmrtKeyLoctnProc</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKeyLoctnProc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b6400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>74</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6ae200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUWKSTS</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6aae00">
                  <SHORT-NAME>SmrtKeyLoctnFlrRsn</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKeyLoctnFlrRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b7e00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f6b9800">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6865xOa505a3f19f25843c4b2f689300">
                  <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_10ms_Group32</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f52a0XOa505a3f19f25843c4b2f529f00">
              <SHORT-NAME>LHZCU_20ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>689411</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.015</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/BrkLghtCtrl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/HzrdLghtSwReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/PriySSBA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/PriySSBAV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/RevsLghtCtrl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_20ms_PDU03/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f530d00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f532800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f54a200">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f54bd00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f54d800">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f54f300">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f552900">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f548700">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDippedBeamActStatus</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f550e00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f539400">
                  <SHORT-NAME>RevsLghtCtrl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f53ca00">
                  <SHORT-NAME>PriySSBA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPriySSBA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f53e500">
                  <SHORT-NAME>PriySSBAV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPriySSBAV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f541b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecySSBA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f543600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecySSBAV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f540000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISSBTrigd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f53af00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRMainBeamLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f537900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILMainBeamLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f546c00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f545100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f534300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f52f200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f52c200">
                  <SHORT-NAME>BrkLghtCtrl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f535e00">
                  <SHORT-NAME>HzrdLghtSwReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHzrdLghtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f52a0xOa505a3f19f25843c4b2f52de00">
                  <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_20ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f395fXOa505a3f19f25843c4b2f395e00">
              <SHORT-NAME>LHZCU_400ms_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU01/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.4</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a4700">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSAutoLoctnCm</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>1</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxN200000119f58e5e9011e05a00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>4</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxN200000119f58e5e9011dfe900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a6200">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSIdficnLrnCm</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>9</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxN200000119f58e5e9011e0ec00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRTireSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxN200000119f58e5e9011e0ca00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLTireSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3ab300">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRTirePrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3ae900">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSWntrMdA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a7d00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLTirePrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a9800">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLTirePrsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a1100">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTirePrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3a2c00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTirePrsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f3ace00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRTirePrsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f39db00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTirePrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f395fxOa505a3f19f25843c4b2f39f600">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTirePrsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b334b8cXOa505a3f19f25843c4b334b8b00">
              <SHORT-NAME>LHZCU_400ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/FLTireTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/FLTireTemV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/FRTireTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/FRTireTemV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/RLTireTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/RLTireTemV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/RRTireTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU03/RRTireTemV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.4</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334bb700">
                  <SHORT-NAME>FLTireTemV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>0</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334b9b00">
                  <SHORT-NAME>FLTireTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334be900">
                  <SHORT-NAME>FRTireTemV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>8</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334bce00">
                  <SHORT-NAME>FRTireTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334c1f00">
                  <SHORT-NAME>RLTireTemV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLTireTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334c0400">
                  <SHORT-NAME>RLTireTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLTireTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334c5500">
                  <SHORT-NAME>RRTireTemV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRTireTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b334b8cxOa505a3f19f25843c4b334c3a00">
                  <SHORT-NAME>RRTireTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRTireTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f6205XOa505a3f19f25843c4b2f620400">
              <SHORT-NAME>LHZCU_400ms_PDU18</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/LHZCU_400ms_Group18_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/LHZCU_400ms_Group18_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/TPMSF</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/TPMSTirePrsLowIO</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_400ms_PDU18/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.4</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f626100">
                  <SHORT-NAME>LHZCU_400ms_Group18_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f627c00">
                  <SHORT-NAME>LHZCU_400ms_Group18_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f621700">
                  <SHORT-NAME>TPMSF</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f624600">
                  <SHORT-NAME>TPMSTirePrsLowIO</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSTirePrsLowIO</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f629700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f62b200">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f62cd00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f62e800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f630300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f631e00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f633900">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6205xOa505a3f19f25843c4b2f623300">
                  <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_400ms_Group18</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f555aXOa505a3f19f25843c4b2f555900">
              <SHORT-NAME>LHZCU_50ms_PDU04</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>689412</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.035</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/BrkLghtSwSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU04/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f567000">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFindCarFuncInfoDsp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>2</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f568b00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDoorHndlPESwtActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f56a600">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDoorHndlPESwtActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f559800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSwStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f557c00">
                  <SHORT-NAME>BrkLghtSwSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f56dc00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrWiperReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f56c100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f55b300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLghtSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f560400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcRlseSwtActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f574800">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDSP_RRWinSwtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f572d00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDSP_RLWinSwtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f571200">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDSP_FRWinSwtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f563a00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlTrigd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f55e900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLWinLclSwtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f55ce00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtrLckActnIndcn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f56f700">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoMainBeamLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f561f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDetSnsrFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f555axOa505a3f19f25843c4b2f565500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLghtMdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f586dXOa505a3f19f25843c4b2f586c00">
              <SHORT-NAME>LHZCU_50ms_PDU06</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>689414</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.035</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/BntOpenSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/DrvrDetSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/DrvrDoorOpenSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/LHZCU_50ms_Group06_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/LHZCU_50ms_Group06_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/RLDoorOpenSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/VehLckSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU06/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f58da00">
                  <SHORT-NAME>LHZCU_50ms_Group06_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f58f500">
                  <SHORT-NAME>LHZCU_50ms_Group06_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f58bf00">
                  <SHORT-NAME>DrvrDetSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDetSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f592b00">
                  <SHORT-NAME>RLDoorOpenSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDoorOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f599700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f591000">
                  <SHORT-NAME>DrvrDoorOpenSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDoorOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f588f00">
                  <SHORT-NAME>BntOpenSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBntOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f594600">
                  <SHORT-NAME>VehLckSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehLckSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f59b200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f59cd00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f5a0300">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f597c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSInitnFltPrst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f59e800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f5a3900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f596100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDirnLghtSftyMonErr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f5a1e00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f5a5400">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f586dxOa505a3f19f25843c4b2f58ab00">
                  <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_50ms_Group06</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f5a84XOa505a3f19f25843c4b2f5a8300">
              <SHORT-NAME>LHZCU_50ms_PDU08</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>689416</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.035</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/LHZCUeFs12DiagSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/SideLghtSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU08/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5c5700">
                  <SHORT-NAME>SideLghtSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISideLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>0</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5ac200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs12Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>3</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5aa600">
                  <SHORT-NAME>LHZCUeFs12DiagSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs12DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5c3c00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw17Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5c2100">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw17DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5c0600">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw16Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5beb00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw16DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5bd000">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw15Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5bb500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw15DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b9a00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw14Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b7f00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw14DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b6400">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw13Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b4900">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw13DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b2e00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw12Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5b1300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeSw12DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5af800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs13Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f5a84xOa505a3f19f25843c4b2f5add00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUeFs13DiagSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f3b19XOa505a3f19f25843c4b2f3b1800">
              <SHORT-NAME>LHZCU_50ms_PDU24</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU24/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c8300">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c9e00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3b7500">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehHzrdMdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3cb900">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved23</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c4d00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehIlluminateCtrlCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3cd400">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved31</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3bfc00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3cef00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved39</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3be100">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d0a00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved47</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d4000">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved49</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3bc600">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c1700">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtMdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d2500">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved55</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d5b00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved60</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3b5a00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRSideLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3b2b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSideLghtCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d7600">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved71</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c6800">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSideLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3d9100">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved79</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3dc700">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved81</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3b9000">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3dac00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved87</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3de200">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved95</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3dfd00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved103</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3bab00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>105</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e1800">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved111</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3c3200">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDLkngAmbtLghtLvlByLux</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e3300">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved121</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>121</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e4e00">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved135</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e6900">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved143</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e8400">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved151</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3e9f00">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved159</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3b19xOa505a3f19f25843c4b2f3b4700">
                  <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_50ms_Group24</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f3ed0XOa505a3f19f25843c4b2f3ecf00">
              <SHORT-NAME>LHZCU_50ms_PDU34</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>689460</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.035</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/AllWndAndSrfLazyClsReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/TrdtnSmrtKyLckSwSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/TrdtnSmrtKyUnlckSwSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU34/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f9500">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoMainBeamLghtOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f2900">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f0e00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILRevsLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3ef200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILBrkLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3fcb00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IROtsdMirVertSwActReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3fb000">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IROtsdMirHoztSwActReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f4400">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDoorLckSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f7a00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZoneRLSideLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3f5f00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZoneFLSideLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f3fe600">
                  <SHORT-NAME>AllWndAndSrfLazyClsReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAllWndAndSrfLazyClsReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f400100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrSrvcPosReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f401c00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrWiperFnEnb</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f412a00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPSelRSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f410f00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPSelLSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f406d00">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdtnSmrtKyLckSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>65</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f408800">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdtnSmrtKyUnlckSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f405200">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSuperLckSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>69</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f403700">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSuperLckSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f40f400">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPSelDwnSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f40d900">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPSelUpSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f40be00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPROtsdMirSeldSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>77</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f40a300">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPLOtsdMirSeldSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f3ed0xOa505a3f19f25843c4b2f414500">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDDSPOtsdMirFoldSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b351d59XOa505a3f19f25843c4b351d5800">
              <SHORT-NAME>LHZCU_50ms_PDU58</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_50ms_PDU58/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351f0100">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdtnKeyBtnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e4400">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey1BtnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e7a00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey2BtnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351eb000">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey3BtnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351ee600">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey4BtnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e9500">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey2LoctnResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e5f00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey1LoctnResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351df300">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHandAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351ecb00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey3LoctnResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351dd800">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtBmpAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e0e00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHandAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351d8700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICabinFrtAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351e2900">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrBmpAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351dbd00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICabinRrAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351da200">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICabinImmoAntFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351d6b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKickSnsrDetnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>91</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351f3700">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdtnSmrtKyLdspcSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>93</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b351d59xOa505a3f19f25843c4b351f1c00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdtnSmrtKyFindCarSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f38b0XOa505a3f19f25843c4b2f38af00">
              <SHORT-NAME>LHZCU_ICBVC_50ms_PDU14</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f38b0xOa505a3f19f25843c4b2f38de00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f38b0xOa505a3f19f25843c4b2f391400">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILMainBeamLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f38b0xOa505a3f19f25843c4b2f38f900">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDipdBeamLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f38b0xOa505a3f19f25843c4b2f392f00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESCLAuthnReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f38b0xOa505a3f19f25843c4b2f38c200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDipdBeamLghtOnReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f30aeXOa505a3f19f25843c4b2f30ad00">
              <SHORT-NAME>PEU_10ms_PDU25</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PEU_10ms_PDU25/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f312700">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f314200">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f31c900">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f310c00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f30c100">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotADampTrqCmdd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f30f100">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f319300">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBDampTrqCmdd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f31ae00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f315d00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAch</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f31ff00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAch</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f323500">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>91</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f32bc00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>106</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f32a100">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>107</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f326b00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>108</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f321a00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAchV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>109</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f31e400">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>110</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f317800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAchV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f325000">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f328600">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexN200000119f8c72e8e0676dc00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved147</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>147</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexN200000119f7cf8b0714361000">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBMdAch</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>149</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexN200000119f7cf8b0714354800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAMdAch</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f32f200">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f30aexOa505a3f19f25843c4b2f30dd00">
                  <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPEU_10ms_Group25</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b329755XOa505a3f19f25843c4b32975400">
              <SHORT-NAME>PICM_100ms_PDU06</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/AISocMngtActv</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/EPTElecWtrPumpActuSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/EndSocTrgtHCU</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/EndSocTrgtHCUV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/TrgtSOCUpdtReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICM_100ms_PDU06/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3297ef00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSModestatus2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3297d400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSModestatus1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32976700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGS1FltRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32978300">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGS2FltRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32979e00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSActualPosition1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3297b900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSActualPosition2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3298e200">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTElecWtrPumpActuSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3298fd00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSElecWtrPumpActuSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3298ac00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUClntTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32989100">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSTorqueResponse2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32987600">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSTorqueResponse1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32985b00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSSelflearnStatus2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>85</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32984000">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSSelflearnStatus1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xN200000119f4464397e2ff0300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBMLifeTimeParmFromEsMaxLmt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>88</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32994e00">
                  <SHORT-NAME>EndSocTrgtHCUV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEndSocTrgtHCUV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>89</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32991800">
                  <SHORT-NAME>AISocMngtActv</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAISocMngtActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32996900">
                  <SHORT-NAME>TrgtSOCUpdtReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSOCUpdtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>91</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32999f00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWCACThrWayVlvActuPosV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>92</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b3298c700">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUClntTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>93</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32982500">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSMoveStatus2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>94</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32980a00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAGSMoveStatus1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32998400">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWCACThrWayVlvActuPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329755xOa505a3f19f25843c4b32993300">
                  <SHORT-NAME>EndSocTrgtHCU</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEndSocTrgtHCU</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b302cd8XOa505a3f19f25843c4b302cd700">
              <SHORT-NAME>PICU_10ms_PDU03</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/DrvrReqFrtAxleWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/DrvrReqFrtAxleWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/DrvrReqRrAxleWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/DrvrReqRrAxleWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/FrtAxleActuWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/FrtAxleActuWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/PICU_10ms_Group03_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/PICU_10ms_Group03_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/PtHVCntarReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/RrAxleActuWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/RrAxleActuWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/TotActuWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/TotActuWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU03/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d3500">
                  <SHORT-NAME>PICU_10ms_Group03_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d5000">
                  <SHORT-NAME>PICU_10ms_Group03_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302dbc00">
                  <SHORT-NAME>FrtAxleActuWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e5e00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d8600">
                  <SHORT-NAME>DrvrReqRrAxleWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d1a00">
                  <SHORT-NAME>DrvrReqFrtAxleWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302cea00">
                  <SHORT-NAME>DrvrReqFrtAxleWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d6b00">
                  <SHORT-NAME>DrvrReqRrAxleWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302da100">
                  <SHORT-NAME>FrtAxleActuWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302df200">
                  <SHORT-NAME>RrAxleActuWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e2800">
                  <SHORT-NAME>TotActuWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e7900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e4300">
                  <SHORT-NAME>TotActuWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>100</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e0d00">
                  <SHORT-NAME>RrAxleActuWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>101</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302dd700">
                  <SHORT-NAME>PtHVCntarReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtHVCntarReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302e9400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302eaf00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302eca00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302ee500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302f0000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302f1b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302f3600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302cd8xOa505a3f19f25843c4b302d0600">
                  <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPICU_10ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33d156XOa505a3f19f25843c4b33d15500">
              <SHORT-NAME>PICU_10ms_PDU23</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/CrkshftNonTrRegdCmddToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnComFlrRducdPwrCmdd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnDclFuelCutOffAld</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnDclFuelCutOffReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnDclFuelCutOffSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnFuelCutA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnFuelRcvrySpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnHybVehStaOvrd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnIdleCtrlA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnIdleCtrlSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnReqdStTyp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnSynRdy</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/EnSysDsbld</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/HybEnSpdReqF</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/HybEnStSpOvrd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/PICU_10ms_Group23_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/PICU_10ms_Group23_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/PtACCA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/RVSEnRunning</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_10ms_PDU23/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d31100">
                  <SHORT-NAME>PICU_10ms_Group23_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d32c00">
                  <SHORT-NAME>PICU_10ms_Group23_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d37d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnStCtrlA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d20300">
                  <SHORT-NAME>EnFuelCutA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelCutA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d2f600">
                  <SHORT-NAME>HybEnStSpOvrd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnStSpOvrd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d2db00">
                  <SHORT-NAME>HybEnSpdReqF</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnSpdReqF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d1b200">
                  <SHORT-NAME>EnDclFuelCutOffAld</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffAld</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d39800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_Reserved18</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d36200">
                  <SHORT-NAME>RVSEnRunning</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSEnRunning</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d23900">
                  <SHORT-NAME>EnHybVehStaOvrd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnHybVehStaOvrd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d2a500">
                  <SHORT-NAME>EnSynRdy</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSynRdy</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d2c000">
                  <SHORT-NAME>EnSysDsbld</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSysDsbld</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d19700">
                  <SHORT-NAME>EnComFlrRducdPwrCmdd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnComFlrRducdPwrCmdd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d34700">
                  <SHORT-NAME>PtACCA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtACCA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d1cd00">
                  <SHORT-NAME>EnDclFuelCutOffReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d1e800">
                  <SHORT-NAME>EnDclFuelCutOffSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d25400">
                  <SHORT-NAME>EnIdleCtrlA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d26f00">
                  <SHORT-NAME>EnIdleCtrlSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d17c00">
                  <SHORT-NAME>CrkshftNonTrRegdCmddToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICrkshftNonTrRegdCmddToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d28a00">
                  <SHORT-NAME>EnReqdStTyp</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnReqdStTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d21e00">
                  <SHORT-NAME>EnFuelRcvrySpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelRcvrySpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33d156xOa505a3f19f25843c4b33d16800">
                  <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IPICU_10ms_Group23</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b303031XOa505a3f19f25843c4b30303000">
              <SHORT-NAME>PICU_20ms_PDU11</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/CstRgtnBrkLgtReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/CstRgtnBrkLgtReqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/HybAPAAvlbl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/MaxAvlblTotWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/MaxAvlblTotWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/MinAvlblTotWhlToq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/MinAvlblTotWhlToqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/PICU_20ms_Group11_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/PICU_20ms_Group11_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/RdundtHybCmddEnToqImmd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/RdundtHybCmddEnToqPrdtd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/RdundtHybCmddEnToqRespTyp</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/PICU_20ms_PDU11/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30314a00">
                  <SHORT-NAME>PICU_20ms_Group11_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30316500">
                  <SHORT-NAME>PICU_20ms_Group11_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30319b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b3030c300">
                  <SHORT-NAME>HybAPAAvlbl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybAPAAvlbl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30312f00">
                  <SHORT-NAME>MinAvlblTotWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b3030f900">
                  <SHORT-NAME>MaxAvlblTotWhlToqV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b3030de00">
                  <SHORT-NAME>MaxAvlblTotWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30311400">
                  <SHORT-NAME>MinAvlblTotWhlToq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b3031b600">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b30308d00">
                  <SHORT-NAME>CstRgtnBrkLgtReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICstRgtnBrkLgtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b303031xOa505a3f19f25843c4b3030a800">
