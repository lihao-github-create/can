                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b944e00">
                          <SHORT-NAME>NmPDU_BKPCANFD_RFSDA</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_RFSDA_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b945900">
                          <SHORT-NAME>NmPDU_BKPCANFD_RHRDA</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_RHRDA_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b903800">
                          <SHORT-NAME>NmPDU_BKPCANFD_ZXD</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_ZXD_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b956d00">
                          <SHORT-NAME>RFSDA_100ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RFSDA_100ms_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_100ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTBSysFltSts_ADAS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTSwSts_ADAS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTSysFltSts_ADAS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LFCTWrnng_ADAS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFCTWrnng_ADAS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b951f00">
                          <SHORT-NAME>RFSDA_20ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RFSDA_20ms_PDU02_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_20ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqSts_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqToqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_CRC_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_RC_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_Group02_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b959900">
                          <SHORT-NAME>RHRDA_50ms_PDU04</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHRDA_50ms_PDU04_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHRDA_50ms_PDU04</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BSDSelSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DOWSelSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LBSDAndLCAWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LCASelSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDOWWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LRCTAWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RBSDAndLCAWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RCTSysSelSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RDASwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RDASysSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RDOWWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_Group04_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLRdrEmgcLineChngWrnng_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRCTAWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRRdrEmgcLineChngWrnng_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrCrnRdrCalSts_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b987100">
                          <SHORT-NAME>RHZCU_100ms_PDU06</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_100ms_PDU06_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU06</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtCamrHeatSts_FrtCamrHeatSts_FrtCamrHeatSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b988700">
                          <SHORT-NAME>RHZCU_100ms_PDU10</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_100ms_PDU10_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU10</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACAmbtTemMsk_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACAmbtTemV_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACAmbtTem_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACComprActuPwr_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSeatHorzPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSeatVertPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_CRC_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_RC_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_Group10_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b987c00">
                          <SHORT-NAME>RHZCU_100ms_PDU15</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_100ms_PDU15_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU15</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DfstOnDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b957800">
                          <SHORT-NAME>RHZCU_100ms_PDU20</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_100ms_PDU20_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU20</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRDoorOpenSts_FRDoorOpenSts_FRDoorOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b916c00">
                          <SHORT-NAME>RHZCU_50ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_50ms_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group01_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw41DiagSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw41Sts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDoorOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b900c00">
                          <SHORT-NAME>RHZCU_50ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_50ms_PDU03_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeFs1Sts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b93b300">
                          <SHORT-NAME>RHZCU_50ms_PDU27</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_50ms_PDU27_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU27</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_Group27_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw33DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw33Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw37DiagSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw37Sts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw3DiagSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw3Sts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw42DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw42Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw43DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw43Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw9DiagSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUeSw9Sts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b901700">
                          <SHORT-NAME>RHZCU_ICBVC_50ms_PDU14</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_ICBVC_50ms_PDU14_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_ICBVC_50ms_PDU14</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRDircnLghtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b955700">
                          <SHORT-NAME>RZCU_50ms_PDU37</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RZCU_50ms_PDU37_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU37</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtFltSts_HW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtSts_HW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ChrgrFlapLtchCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LdspcOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LdspcOpenStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PwrLftgtClsSwtActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDircnLghtFltsts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDircnLghtFltsts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDircnLghtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDircnLghtSts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDircnLghtFltsts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDircnLghtFltsts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDircnLghtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDircnLghtSts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_CRC_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_RC_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved34</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved36</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved38</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_Group37_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RearFogLghtFltsts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RearFogLghtSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RevsLghtFltSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RevsLghtSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a03148f4f31ca6b00">
                          <SHORT-NAME>SecuredIPdu_ICC_SecOC_SyncMsg</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="SECURED-I-PDU">/Communication/PDUs/SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b961200">
                          <SHORT-NAME>TPMS_400ms_PDU06</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/TPMS_400ms_PDU06_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TPMS_400ms_PDU06</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSBtmNosRSSI</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSSnsrID</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSSnsrIDLoctn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSSnsrRSSI</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSSnsrRdoFrqcCtr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSSnsrRdoFrqcCtrLoctn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b961d00">
                          <SHORT-NAME>Teter_ECM_10ms_PDU20</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Teter_ECM_10ms_PDU20_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/Teter_ECM_10ms_PDU20</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/En12VoltStrMotCmddOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b917700">
                          <SHORT-NAME>ZXD_100ms_PDU76</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_100ms_PDU76_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU76</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpedRegulaModSwReq_SpedRegulaModSwReq_SpedRegulaModSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e339ca00">
                          <SHORT-NAME>ZXD_100ms_PDU77</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_100ms_PDU77_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU77</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMSwReq_Reserve16_ICMSwReq_Reserve16_ICMSwReq_Reserve16</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMSwReq_Reserve17_ICMSwReq_Reserve17_ICMSwReq_Reserve17</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                      </PDU-TRIGGERINGS>
                    </CAN-PHYSICAL-CHANNEL>
                  </PHYSICAL-CHANNELS>
                  <CAN-FD-BAUDRATE>2000000</CAN-FD-BAUDRATE>
                </CAN-CLUSTER-CONDITIONAL>
              </CAN-CLUSTER-VARIANTS>
            </CAN-CLUSTER>
            <CAN-CLUSTER UUID="Oa505a3f19f25843c4b3f897aXOa505a3f19f25843c4b3f897900">
              <SHORT-NAME>CHCANFD</SHORT-NAME>
              <CAN-CLUSTER-VARIANTS>
                <CAN-CLUSTER-CONDITIONAL>
                  <BAUDRATE>500000</BAUDRATE>
                  <PHYSICAL-CHANNELS>
                    <CAN-PHYSICAL-CHANNEL UUID="Oa505a3f19f25843c4b3f898dXOa505a3f19f25843c4b3f898c00">
                      <SHORT-NAME>CHCANFD</SHORT-NAME>
                      <COMM-CONNECTORS>
                        <COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                          <COMMUNICATION-CONNECTOR-REF DEST="CAN-COMMUNICATION-CONNECTOR">/Topology/HardwareComponents/IPD/IPD_CHCANFD</COMMUNICATION-CONNECTOR-REF>
                        </COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                      </COMM-CONNECTORS>
                      <FRAME-TRIGGERINGS>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395a8c00">
                          <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_CHCANFD_10ms_ConFrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/EPS_CHCANFD_10ms_ConFrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_ZONE_CHCANFD_10ms_Container01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>429</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39672c00">
                          <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP05</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_CHCANFD_10ms_ConFrP05_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/EPS_CHCANFD_10ms_ConFrP05</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/SAS_ZONE_CHCANFD_10ms_Container01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>173</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39637600">
                          <SHORT-NAME>EPS_CHCANFD_20ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_CHCANFD_20ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/EPS_CHCANFD_20ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_20ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>430</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395afe00">
                          <SHORT-NAME>EPS_CHCANFD_CT_Tx</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_CHCANFD_CT_Tx_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/EPS_CHCANFD_CT_Tx</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_CHCANFD_CT_Tx1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1681</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395eda00">
                          <SHORT-NAME>EPS_CHCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_CHCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/EPS_CHCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/NmPDU_CHCANFD_EPS</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1252</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3969fc00">
                          <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP05</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_BKPCANFD_100ms_FrP05_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FVCM_BKPCANFD_100ms_FrP05</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/FVCM_100ms_PDU05</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>956</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395c0800">
                          <SHORT-NAME>FVCM_BKPCANFD_10ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_BKPCANFD_10ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FVCM_BKPCANFD_10ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/FVCM_10ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>163</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395c5400">
                          <SHORT-NAME>IBS_CHCANFD_100ms_FrP15</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_100ms_FrP15_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_100ms_FrP15</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_100ms_PDU15</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>988</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39656400">
                          <SHORT-NAME>IBS_CHCANFD_10ms_ConFrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_10ms_ConFrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_10ms_ConFrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_CHCANFD_10ms_Container01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>184</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3964a600">
                          <SHORT-NAME>IBS_CHCANFD_10ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_10ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_10ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_10ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>318</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3964cc00">
                          <SHORT-NAME>IBS_CHCANFD_10ms_FrP02</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_10ms_FrP02_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_10ms_FrP02</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_10ms_PDU02</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>319</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39677800">
                          <SHORT-NAME>IBS_CHCANFD_20ms_ConFrP10</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_ConFrP10_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_ConFrP10</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_CHCANFD_20ms_Container01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>394</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39684200">
                          <SHORT-NAME>IBS_CHCANFD_20ms_FrP07</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_FrP07_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_FrP07</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU07</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>423</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39613400">
                          <SHORT-NAME>IBS_CHCANFD_20ms_FrP08</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_FrP08_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_FrP08</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU08</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>342</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39610e00">
                          <SHORT-NAME>IBS_CHCANFD_20ms_FrP09</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_FrP09_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_FrP09</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU09</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>329</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39681800">
                          <SHORT-NAME>IBS_CHCANFD_20ms_FrP11</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_FrP11_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_FrP11</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU11</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>425</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39615a00">
                          <SHORT-NAME>IBS_CHCANFD_20ms_FrP12</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_20ms_FrP12_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_20ms_FrP12</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU12</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>339</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395f0800">
                          <SHORT-NAME>IBS_CHCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_CHCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_CHCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/NmPDU_CHCANFD_IBS</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1272</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3965b000">
                          <SHORT-NAME>IBS_SFCANFD_20ms_FrP26</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_SFCANFD_20ms_FrP26_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_SFCANFD_20ms_FrP26</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU26</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>283</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3960ba00">
                          <SHORT-NAME>IBS_ZONE_CHCANFD_20ms_FrP08</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_CHCANFD_20ms_FrP08_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IBS_ZONE_CHCANFD_20ms_FrP08</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_ZONE_20ms_PDU08</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>507</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3965fc00">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_BKPCANFD_20ms_FrP07_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP07</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU07</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>382</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xN200000119f4464397e3394100">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP09</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_BKPCANFD_20ms_FrP09_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP09</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU09</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>385</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395d3800">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_BKPCANFD_20ms_FrP46_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP46</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU46</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>343</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39686c00">
                          <SHORT-NAME>ICBAD_CHCANFD_10ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_CHCANFD_10ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_10ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_10ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>102</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xN200000119f4464397e31e2d00">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_CHCANFD_20ms_FrP13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>360</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39626c00">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP16</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_CHCANFD_20ms_FrP16_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP16</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU16</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1122</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395d5e00">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP48</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_CHCANFD_20ms_FrP48_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP48</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU48</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>474</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395d8400">
                          <SHORT-NAME>ICBAD_CHCANFD_Event_FrS03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_CHCANFD_Event_FrS03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_Event_FrS03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_Sporadic_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>47</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3968ea00">
                          <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_RZCUCANFD_20ms_FrP12_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_RZCUCANFD_20ms_FrP12</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_20ms_PDU12</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>424</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39629200">
                          <SHORT-NAME>ICBAD_RZCUCANFD_50ms_FrP21</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_RZCUCANFD_50ms_FrP21_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_RZCUCANFD_50ms_FrP21</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_50ms_PDU21</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>520</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395daa00">
                          <SHORT-NAME>ICBAD_ZONE_CHCANFD_10ms_FrP20</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_CHCANFD_10ms_FrP20_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_ZONE_CHCANFD_10ms_FrP20</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_ZONE_10ms_PDU20</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>98</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39653e00">
                          <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_CHCANFD_20ms_FrP13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_ZONE_CHCANFD_20ms_FrP13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/ICBAD_ZONE_20ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>81</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b396a4800">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP35</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_BKPCANFD_100ms_FrP35_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP35</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IPD_100ms_PDU35</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>807</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3965d600">
                          <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_BKPCANFD_20ms_FrP43_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_20ms_FrP43</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IPD_20ms_PDU43</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>486</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b396a2200">
                          <SHORT-NAME>IPD_BKPCANFD_20ms_FrP60</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_BKPCANFD_20ms_FrP60_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_20ms_FrP60</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IPD_20ms_PDU60</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>337</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xN20000011a02779c9f444c7f00">
                          <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_BKPCANFD_50ms_FrP49_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_50ms_FrP49</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IPD_50ms_PDU49</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>733</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39664800">
                          <SHORT-NAME>IPD_BKPCANFD_50ms_FrP62</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_BKPCANFD_50ms_FrP62_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_50ms_FrP62</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IPD_50ms_PDU62</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>590</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3960e000">
                          <SHORT-NAME>IPD_CHCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_CHCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_CHCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/NmPDU_CHCANFD_IPD</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1202</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39623e00">
                          <SHORT-NAME>RZCU_CHCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/RZCU_CHCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_CHCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/NmPDU_CHCANFD_RZCU</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1267</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3963e800">
                          <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP64</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/RZCU_RZCUCANFD_10ms_FrP64_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_RZCUCANFD_10ms_FrP64</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/RZCU_10ms_PDU64</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>143</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b395f3600">
                          <SHORT-NAME>ZXD_CHCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ZXD_CHCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ZXD_CHCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/NmPDU_CHCANFD_ZXD</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1216</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                      </FRAME-TRIGGERINGS>
                      <I-SIGNAL-TRIGGERINGS>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39220400">
                          <SHORT-NAME>ABSA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ABSA_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39221300">
                          <SHORT-NAME>ABSF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ABSF_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39222200">
                          <SHORT-NAME>ABSIO</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ABSIO_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSIO</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39488900">
                          <SHORT-NAME>ACCAccReqSts_CH</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCAccReqSts_CH_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqSts_CH</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39410900">
                          <SHORT-NAME>ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39489800">
                          <SHORT-NAME>ACCAccReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCAccReqVal_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2088500">
                          <SHORT-NAME>ACCBrkngA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCBrkngA_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCBrkngA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948a700">
                          <SHORT-NAME>ACCGoReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCGoReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948b600">
                          <SHORT-NAME>ACCSdslReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCSdslReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSdslReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392beb00">
                          <SHORT-NAME>ACCStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948c500">
                          <SHORT-NAME>ACCSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCSysFltSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39411800">
                          <SHORT-NAME>ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts_SCS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948d400">
                          <SHORT-NAME>ACCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCSysSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393ce600">
                          <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393cf500">
                          <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392c0900">
                          <SHORT-NAME>ACSFCatgrAStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrAStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrAStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392bbe00">
                          <SHORT-NAME>ACSFCatgrB1StsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrB1StsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrB1StsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392bdc00">
                          <SHORT-NAME>ACSFCatgrB2StsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrB2StsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrB2StsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b9100">
                          <SHORT-NAME>ACSFCatgrCStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrCStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrCStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392ba000">
                          <SHORT-NAME>ACSFCatgrDStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrDStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrDStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392bfa00">
                          <SHORT-NAME>ACSFCatgrEStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ACSFCatgrEStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACSFCatgrEStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b2300">
                          <SHORT-NAME>ADASStrgDlvrdToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ADASStrgDlvrdToq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b3200">
                          <SHORT-NAME>ADASStrgDlvrdToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ADASStrgDlvrdToqV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949b500">
                          <SHORT-NAME>AEBBrkJerkLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBBrkJerkLvlReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBBrkJerkLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949c400">
                          <SHORT-NAME>AEBDclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBDclReqSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949a600">
                          <SHORT-NAME>AEBDclReqToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBDclReqToqVal_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949d300">
                          <SHORT-NAME>AEBDclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBDclReqVal_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949e200">
                          <SHORT-NAME>AEBHydBrkAstLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBHydBrkAstLvlReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBHydBrkAstLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3949f100">
                          <SHORT-NAME>AEBPrflReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBPrflReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBPrflReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b8200">
                          <SHORT-NAME>AEBStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394a0000">
                          <SHORT-NAME>AEBSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBSysFltSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394a0f00">
                          <SHORT-NAME>AEBSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AEBSysSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948e300">
                          <SHORT-NAME>AIPkgAPASCSAcclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AIPkgAPASCSAcclReqVal_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPkgAPASCSAcclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393fea00">
                          <SHORT-NAME>ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393ffa00">
                          <SHORT-NAME>ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb285ae00">
                          <SHORT-NAME>APACmdEPSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APACmdEPSSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACmdEPSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3948f200">
                          <SHORT-NAME>APAEPBOPReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAEPBOPReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39490100">
                          <SHORT-NAME>APAEPBOPReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAEPBOPReqV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39482000">
                          <SHORT-NAME>APAEnRunReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAEnRunReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnRunReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb285e200">
                          <SHORT-NAME>APAF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAF_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39491000">
                          <SHORT-NAME>APASCSAcclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APASCSAcclReqSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSAcclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39400a00">
                          <SHORT-NAME>APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2861600">
                          <SHORT-NAME>APASCUReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APASCUReqSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2864a00">
                          <SHORT-NAME>APASCUReqStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APASCUReqStsV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2867e00">
                          <SHORT-NAME>APAShifterPosReqd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAShifterPosReqd_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb286b200">
                          <SHORT-NAME>APAShifterPosReqdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAShifterPosReqdV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39371500">
                          <SHORT-NAME>APASts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APASts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb286e600">
                          <SHORT-NAME>APATrgtEPSStrgWhlAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APATrgtEPSStrgWhlAng_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATrgtEPSStrgWhlAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39401a00">
                          <SHORT-NAME>APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatAzmth</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39402a00">
                          <SHORT-NAME>APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosX</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39403a00">
                          <SHORT-NAME>APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosY</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921d700">
                          <SHORT-NAME>AVHSigPdlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AVHSigPdlSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVHSigPdlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39310400">
                          <SHORT-NAME>AccelerationXsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationXsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationXsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39311300">
                          <SHORT-NAME>AccelerationXsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationXsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationXsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39312200">
                          <SHORT-NAME>AccelerationYsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationYsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationYsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39313100">
                          <SHORT-NAME>AccelerationYsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationYsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationYsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39314000">
                          <SHORT-NAME>AccelerationZsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationZsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationZsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39314f00">
                          <SHORT-NAME>AccelerationZsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AccelerationZsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationZsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ae700">
                          <SHORT-NAME>ActuPnonAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuPnonAng_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391af600">
                          <SHORT-NAME>ActuPnonAngV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuPnonAngV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b0500">
                          <SHORT-NAME>ActuRoadWhlAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuRoadWhlAng_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a1500">
                          <SHORT-NAME>ActuRoadWhlAngGrd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuRoadWhlAngGrd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a2400">
                          <SHORT-NAME>ActuRoadWhlAngGrdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuRoadWhlAngGrdV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b1400">
                          <SHORT-NAME>ActuRoadWhlAngV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ActuRoadWhlAngV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39315e00">
                          <SHORT-NAME>AngularRateXsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateXsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateXsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39316d00">
                          <SHORT-NAME>AngularRateXsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateXsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateXsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39317c00">
                          <SHORT-NAME>AngularRateYsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateYsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateYsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39318b00">
                          <SHORT-NAME>AngularRateYsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateYsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateYsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39319a00">
                          <SHORT-NAME>AngularRateZsecinfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateZsecinfo_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateZsecinfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3931a900">
                          <SHORT-NAME>AngularRateZsecinfoV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AngularRateZsecinfoV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateZsecinfoV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39223100">
                          <SHORT-NAME>AutoHoldMdSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutoHoldMdSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldMdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39224000">
                          <SHORT-NAME>AutoHoldMsg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutoHoldMsg_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldMsg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39224f00">
                          <SHORT-NAME>AutoHoldSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutoHoldSysSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39404a00">
                          <SHORT-NAME>AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngLLaneSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39405a00">
                          <SHORT-NAME>AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngRLaneSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39484d00">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysEmgcBrkReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39485c00">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysEmgcBrkReqV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39491f00">
                          <SHORT-NAME>AutodDrvngSysFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysFlrSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39492e00">
                          <SHORT-NAME>AutodDrvngSysFlrStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysFlrStsV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39493d00">
                          <SHORT-NAME>AutodDrvngSysMdReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysMdReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b208b900">
                          <SHORT-NAME>AutodDrvngSysMdReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysMdReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b208ed00">
                          <SHORT-NAME>AutodDrvngSysMdReqRespV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysMdReqRespV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqRespV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39494c00">
                          <SHORT-NAME>AutodDrvngSysMdReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysMdReqV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39495b00">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysSCSDrvOffReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39496a00">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysSCSDrvOffReqV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39497900">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysSCSSdslReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39498800">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysSCSSdslReqV_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39372400">
                          <SHORT-NAME>AutodDrvngSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393fcb00">
                          <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392e7f00">
                          <SHORT-NAME>BrkBstFnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkBstFnSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkBstFnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920ab00">
                          <SHORT-NAME>BrkDiscTemSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkDiscTemSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkDiscTemSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392dad00">
                          <SHORT-NAME>BrkFltAlrm_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkFltAlrm_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFltAlrm_GB</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920ba00">
                          <SHORT-NAME>BrkFludLvlLow</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkFludLvlLow_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFludLvlLow</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920c900">
                          <SHORT-NAME>BrkFludLvlLowV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkFludLvlLowV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFludLvlLowV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392dbc00">
                          <SHORT-NAME>BrkFrc_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkFrc_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFrc_GB</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920d800">
                          <SHORT-NAME>BrkPdlAppd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlAppd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlAppd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920e700">
                          <SHORT-NAME>BrkPdlAppdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlAppdV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlAppdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3920f600">
                          <SHORT-NAME>BrkPdlDrvrAppdPrs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlDrvrAppdPrs_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39210500">
                          <SHORT-NAME>BrkPdlDrvrAppdPrsDet</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlDrvrAppdPrsDet_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsDet</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39211400">
                          <SHORT-NAME>BrkPdlDrvrAppdPrsDetV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlDrvrAppdPrsDetV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsDetV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39212300">
                          <SHORT-NAME>BrkPdlDrvrAppdPrsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlDrvrAppdPrsV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39213200">
                          <SHORT-NAME>BrkPdlMdlActSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlMdlActSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlMdlActSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39214100">
                          <SHORT-NAME>BrkPdlMdlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlMdlSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlMdlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e7c00">
                          <SHORT-NAME>BrkPdlPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlPos_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e8d00">
                          <SHORT-NAME>BrkPdlPosV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlPosV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlPosV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39215000">
                          <SHORT-NAME>BrkPdlSimltdPrs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlSimltdPrs_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlSimltdPrs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39215f00">
                          <SHORT-NAME>BrkPdlSimltdPrsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkPdlSimltdPrsV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlSimltdPrsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e9e00">
                          <SHORT-NAME>BrkSysBrkLghtsReqd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysBrkLghtsReqd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysBrkLghtsReqd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39225e00">
                          <SHORT-NAME>BrkSysHillStAstAvlbl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysHillStAstAvlbl_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysHillStAstAvlbl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39226d00">
                          <SHORT-NAME>BrkSysHillStAstSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysHillStAstSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysHillStAstSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2074d00">
                          <SHORT-NAME>BrkSysRddySysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysRddySysSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysRddySysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39227c00">
                          <SHORT-NAME>BrkSysRedBrkTlltReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysRedBrkTlltReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysRedBrkTlltReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39228b00">
                          <SHORT-NAME>BrkSysYlwBrkTlltReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/BrkSysYlwBrkTlltReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysYlwBrkTlltReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b5000">
                          <SHORT-NAME>CHLKAHptResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/CHLKAHptResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICHLKAHptResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392baf00">
                          <SHORT-NAME>CSFStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/CSFStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICSFStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2092100">
                          <SHORT-NAME>ChACCAccReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChACCAccReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChACCAccReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2095500">
                          <SHORT-NAME>ChACCReqFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChACCReqFlrSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChACCReqFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2098900">
                          <SHORT-NAME>ChAEBBrkJerkReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChAEBBrkJerkReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBBrkJerkReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b209bd00">
                          <SHORT-NAME>ChAEBDclReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChAEBDclReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBDclReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b209f100">
                          <SHORT-NAME>ChAEBHydBrkAstReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChAEBHydBrkAstReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBHydBrkAstReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20a2500">
                          <SHORT-NAME>ChAEBPrflReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChAEBPrflReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBPrflReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20d3100">
                          <SHORT-NAME>ChEBADclReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChEBADclReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChEBADclReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b4100">
                          <SHORT-NAME>ChLKAAngReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChLKAAngReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAAngReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b5f00">
                          <SHORT-NAME>ChLKAToqReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChLKAToqReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAToqReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20a5900">
                          <SHORT-NAME>ChRCTBDclReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChRCTBDclReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChRCTBDclReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20a8d00">
                          <SHORT-NAME>ChRCTBPrflReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChRCTBPrflReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChRCTBPrflReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393cc400">
                          <SHORT-NAME>ChSysEnToqReqProtn_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysEnToqReqProtn_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysEnToqReqProtn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39289400">
                          <SHORT-NAME>ChSysSecyBrkAxleToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysSecyBrkAxleToqVal_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysSecyBrkAxleToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928a300">
                          <SHORT-NAME>ChSysSecyBrkAxleToqValV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysSecyBrkAxleToqValV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysSecyBrkAxleToqValV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391f1500">
                          <SHORT-NAME>ChSysTotBrkAxleToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysTotBrkAxleToqVal_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTotBrkAxleToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391f2600">
                          <SHORT-NAME>ChSysTotBrkAxleToqValV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysTotBrkAxleToqValV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTotBrkAxleToqValV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928b200">
                          <SHORT-NAME>ChSysTrBrkAxleToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysTrBrkAxleToqVal_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTrBrkAxleToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928c100">
                          <SHORT-NAME>ChSysTrBrkAxleToqValV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ChSysTrBrkAxleToqValV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTrBrkAxleToqValV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b7300">
                          <SHORT-NAME>CsbLvlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/CsbLvlSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICsbLvlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b1900">
                          <SHORT-NAME>DistRCAvgDrvn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DistRCAvgDrvn_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b2800">
                          <SHORT-NAME>DistRCAvgDrvnRstOcd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DistRCAvgDrvnRstOcd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnRstOcd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b3700">
                          <SHORT-NAME>DistRCAvgDrvnSrc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DistRCAvgDrvnSrc_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnSrc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b4600">
                          <SHORT-NAME>DistRCAvgDrvnV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DistRCAvgDrvnV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39218c00">
                          <SHORT-NAME>DrvrReqOtptRodTrvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DrvrReqOtptRodTrvl_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqOtptRodTrvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39219b00">
                          <SHORT-NAME>DrvrReqOtptRodTrvlSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DrvrReqOtptRodTrvlSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqOtptRodTrvlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b6e00">
                          <SHORT-NAME>DrvrStrgDlvrdToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DrvrStrgDlvrdToq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b7d00">
                          <SHORT-NAME>DrvrStrgDlvrdToqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/DrvrStrgDlvrdToqV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39229a00">
                          <SHORT-NAME>EBDA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EBDA_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBDA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922a900">
                          <SHORT-NAME>EBDFaultSt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EBDFaultSt_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBDFaultSt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928ee00">
                          <SHORT-NAME>EPBAPAAvlbl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBAPAAvlbl_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAPAAvlbl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928fd00">
                          <SHORT-NAME>EPBAppcnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBAppcnSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAppcnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392e8e00">
                          <SHORT-NAME>EPBAppcnSts_M</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBAppcnSts_M_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAppcnSts_M</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39290c00">
                          <SHORT-NAME>EPBAvlblySts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBAvlblySts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAvlblySts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39291b00">
                          <SHORT-NAME>EPBCCCanclReqd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBCCCanclReqd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBCCCanclReqd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39292a00">
                          <SHORT-NAME>EPBFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBFlrSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39293900">
                          <SHORT-NAME>EPBSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39294800">
                          <SHORT-NAME>EPBSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSwSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39295700">
                          <SHORT-NAME>EPBSwStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSwStsV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSwStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39296600">
                          <SHORT-NAME>EPBSysAudWrnngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSysAudWrnngReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysAudWrnngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393cd500">
                          <SHORT-NAME>EPBSysBrkLghtsReqdA_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSysBrkLghtsReqdA_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysBrkLghtsReqdA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39297500">
                          <SHORT-NAME>EPBSysDspMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSysDspMsgReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysDspMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39298400">
                          <SHORT-NAME>EPBSysStsIndReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSysStsIndReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysStsIndReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39299300">
                          <SHORT-NAME>EPBSysWrnngIndReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPBSysWrnngIndReq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysWrnngIndReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919ac00">
                          <SHORT-NAME>EPSAESReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAESReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919ca00">
                          <SHORT-NAME>EPSAESReqTorResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAESReqTorResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919d900">
                          <SHORT-NAME>EPSAESReqTorRespV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAESReqTorRespV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorRespV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919bb00">
                          <SHORT-NAME>EPSAESStsInh</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAESStsInh_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESStsInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a7e00">
                          <SHORT-NAME>EPSAIPkgAngReqResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPkgAngReqResp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a3300">
                          <SHORT-NAME>EPSAIPkgAngReqRespInh</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPkgAngReqRespInh_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqRespInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a8d00">
                          <SHORT-NAME>EPSAIPltAngRespSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPltAngRespSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a9c00">
                          <SHORT-NAME>EPSAIPltAngRespStsInh</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPltAngRespStsInh_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespStsInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a4200">
                          <SHORT-NAME>EPSAIPltAvlLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPltAvlLvl_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAvlLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a5100">
                          <SHORT-NAME>EPSAIPltCtrlChannel</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAIPltCtrlChannel_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltCtrlChannel</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392cae00">
                          <SHORT-NAME>EPSAPAInh_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAPAInh_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPAInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392cbd00">
                          <SHORT-NAME>EPSAPASts_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSAPASts_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPASts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392f3300">
                          <SHORT-NAME>EPSActRetMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSActRetMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392f2400">
                          <SHORT-NAME>EPSActRetMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSActRetMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c4000">
                          <SHORT-NAME>EPSCTTX</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSCTTX_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCTTX</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b8c00">
                          <SHORT-NAME>EPSCoDrivingSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSCoDrivingSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCoDrivingSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391b9b00">
                          <SHORT-NAME>EPSCurntDrvMd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSCurntDrvMd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCurntDrvMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391baa00">
                          <SHORT-NAME>EPSDrvngMdCtrlInh</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSDrvngMdCtrlInh_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSDrvngMdCtrlInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391bb900">
                          <SHORT-NAME>EPSFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSFlrSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392f5100">
                          <SHORT-NAME>EPSLimMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSLimMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392f4200">
                          <SHORT-NAME>EPSLimMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSLimMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391bc800">
                          <SHORT-NAME>EPSPriyChnlFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSPriyChnlFlrSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSPriyChnlFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c5e00">
                          <SHORT-NAME>EPSToqAppdCoefnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSToqAppdCoefnt_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqAppdCoefnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391bd700">
                          <SHORT-NAME>EPSToqValAldMax</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSToqValAldMax_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMax</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391be600">
                          <SHORT-NAME>EPSToqValAldMaxV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSToqValAldMaxV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMaxV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391bf500">
                          <SHORT-NAME>EPSToqValAldMin</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSToqValAldMin_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMin</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c0400">
                          <SHORT-NAME>EPSToqValAldMinV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSToqValAldMinV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMinV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39252e00">
                          <SHORT-NAME>EPSVMCAngRespSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSVMCAngRespSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCAngRespSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39253d00">
                          <SHORT-NAME>EPSVMCCodrivingSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSVMCCodrivingSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCCodrivingSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39254c00">
                          <SHORT-NAME>EPSVMCRespStsInh_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPSVMCRespStsInh_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCRespStsInh</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39199d00">
                          <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_010ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919e800">
                          <SHORT-NAME>EPS_010ms_Group03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3919f700">
                          <SHORT-NAME>EPS_010ms_Group03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39354600">
                          <SHORT-NAME>EPS_010ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39355100">
                          <SHORT-NAME>EPS_010ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39355c00">
                          <SHORT-NAME>EPS_010ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_010ms_Group03_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ad800">
                          <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c2200">
                          <SHORT-NAME>EPS_10ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c3100">
                          <SHORT-NAME>EPS_10ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39336c00">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39337b00">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39338a00">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39339900">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved4_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933a800">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved5_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933b700">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved6_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933c600">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved7_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933d500">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved8_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933e400">
                          <SHORT-NAME>EPS_10ms_Group01_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group01_Reserved9_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a0600">
                          <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group02_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391aab00">
                          <SHORT-NAME>EPS_10ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group02_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391aba00">
                          <SHORT-NAME>EPS_10ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group02_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a6000">
                          <SHORT-NAME>EPS_10ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group02_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391a6f00">
                          <SHORT-NAME>EPS_10ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group02_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3946d000">
                          <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_10ms_Group05</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39477500">
                          <SHORT-NAME>EPS_10ms_Group05_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39478400">
                          <SHORT-NAME>EPS_10ms_Group05_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3946df00">
                          <SHORT-NAME>EPS_10ms_Group05_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3946ee00">
                          <SHORT-NAME>EPS_10ms_Group05_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3946fd00">
                          <SHORT-NAME>EPS_10ms_Group05_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_10ms_Group05_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392c9000">
                          <SHORT-NAME>EPS_20ms_Group03_CRC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_CRC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392c8100">
                          <SHORT-NAME>EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IEPS_20ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392c9f00">
                          <SHORT-NAME>EPS_20ms_Group03_RC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_RC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933f300">
                          <SHORT-NAME>EPS_20ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3933fe00">
                          <SHORT-NAME>EPS_20ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39340900">
                          <SHORT-NAME>EPS_20ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39341400">
                          <SHORT-NAME>EPS_20ms_Group03_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_Reserved4_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39341f00">
                          <SHORT-NAME>EPS_20ms_Group03_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EPS_20ms_Group03_Reserved5_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392bcd00">
                          <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ESFStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESFStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39406a00">
                          <SHORT-NAME>ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDirInd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39407a00">
                          <SHORT-NAME>ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDrvrTkovReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39408a00">
                          <SHORT-NAME>ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39409a00">
                          <SHORT-NAME>ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922b800">
                          <SHORT-NAME>EmgcBrkA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EmgcBrkA_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922c700">
                          <SHORT-NAME>EmgcBrkAV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EmgcBrkAV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkAV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2078100">
                          <SHORT-NAME>EmgcBrkReqdByIECUSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EmgcBrkReqdByIECUSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkReqdByIECUSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922d600">
                          <SHORT-NAME>EnDragToqRducnA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/EnDragToqRducnA_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDragToqRducnA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20ac100">
                          <SHORT-NAME>ExtnlBrkPrio</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ExtnlBrkPrio_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtnlBrkPrio</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20af500">
                          <SHORT-NAME>ExtnlBrkPrioV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ExtnlBrkPrioV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtnlBrkPrioV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ca900">
                          <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFVCM_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391cf400">
                          <SHORT-NAME>FVCM_10ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d0300">
                          <SHORT-NAME>FVCM_10ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39342a00">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39343500">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39344000">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39344b00">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39345600">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39346100">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39346c00">
                          <SHORT-NAME>FVCM_10ms_Group01_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FVCM_10ms_Group01_Reserved7_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39412700">
                          <SHORT-NAME>FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922e500">
                          <SHORT-NAME>HBAActiveSt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/HBAActiveSt_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHBAActiveSt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3922f400">
                          <SHORT-NAME>HBAValidSt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/HBAValidSt_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHBAValidSt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39230300">
                          <SHORT-NAME>HDCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/HDCSysSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHDCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39413600">
                          <SHORT-NAME>IBSABSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBSABSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSABSlvlResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b20b2900">
                          <SHORT-NAME>IBSAPASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBSAPASysFltSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSAPASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39414500">
                          <SHORT-NAME>IBSESPlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBSESPlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSESPlvlResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392ebb00">
                          <SHORT-NAME>IBSRespAccToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBSRespAccToqVal_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSRespAccToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39415400">
                          <SHORT-NAME>IBSTCSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBSTCSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSTCSlvlResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b0a00">
                          <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_100ms_Group15</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b5500">
                          <SHORT-NAME>IBS_100ms_Group15_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392b6400">
                          <SHORT-NAME>IBS_100ms_Group15_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3945cd00">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3945d800">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3945e300">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3945ee00">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved4_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3945f900">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved5_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39460400">
                          <SHORT-NAME>IBS_100ms_Group15_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_100ms_Group15_Reserved6_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39395e00">
                          <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group01_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a2100">
                          <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_10ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group02_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e6b00">
                          <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_10ms_Group04</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391eaf00">
                          <SHORT-NAME>IBS_10ms_Group04_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ec000">
                          <SHORT-NAME>IBS_10ms_Group04_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d1300">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d2400">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d3500">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d4600">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved4_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d5700">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved5_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d6800">
                          <SHORT-NAME>IBS_10ms_Group04_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_10ms_Group04_Reserved6_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921c800">
                          <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group07</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group07_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921e600">
                          <SHORT-NAME>IBS_20ms_Group07_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group07_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group07_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921f500">
                          <SHORT-NAME>IBS_20ms_Group07_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group07_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group07_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3935f800">
                          <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group08</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group08_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928d000">
                          <SHORT-NAME>IBS_20ms_Group08_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group08_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group08_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3928df00">
                          <SHORT-NAME>IBS_20ms_Group08_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group08_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group08_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ed100">
                          <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group09</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group09_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ef300">
                          <SHORT-NAME>IBS_20ms_Group09_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group09_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391f0400">
                          <SHORT-NAME>IBS_20ms_Group09_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group09_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ee200">
                          <SHORT-NAME>IBS_20ms_Group09_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group09_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39209c00">
                          <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group10</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group10_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921aa00">
                          <SHORT-NAME>IBS_20ms_Group10_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group10_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3921b900">
                          <SHORT-NAME>IBS_20ms_Group10_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group10_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39216e00">
                          <SHORT-NAME>IBS_20ms_Group10_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group10_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39217d00">
                          <SHORT-NAME>IBS_20ms_Group10_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group10_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392dcb00">
                          <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group11</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group11_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392de900">
                          <SHORT-NAME>IBS_20ms_Group11_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group11_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392df800">
                          <SHORT-NAME>IBS_20ms_Group11_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group11_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392dda00">
                          <SHORT-NAME>IBS_20ms_Group11_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group11_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391fbf00">
                          <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group12</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group12_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ff200">
                          <SHORT-NAME>IBS_20ms_Group12_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group12_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39200300">
                          <SHORT-NAME>IBS_20ms_Group12_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group12_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391fd000">
                          <SHORT-NAME>IBS_20ms_Group12_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group12_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391fe100">
                          <SHORT-NAME>IBS_20ms_Group12_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group12_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2071300">
                          <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group13_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2081d00">
                          <SHORT-NAME>IBS_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group13_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f8755c01b2085100">
                          <SHORT-NAME>IBS_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_20ms_Group13_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392e7000">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIBS_ZONE_20ms_Group08</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392e9d00">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_CRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392eac00">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_RC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3934c400">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_Reserved1_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3934d300">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_Reserved2_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3934e200">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_Reserved3_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3934f100">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_Reserved4_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39350000">
                          <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IBS_ZONE_20ms_Group08_Reserved5_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c4f00">
                          <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c8b00">
                          <SHORT-NAME>ICBAD_10ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391c9a00">
                          <SHORT-NAME>ICBAD_10ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394f9b00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394ffe00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved10_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39500900">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved11_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39501400">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved12_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39501f00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved13_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39502a00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved14_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39503500">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved15_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39504000">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved16</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved16_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved16</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39504b00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved17</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved17_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved17</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39505600">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved18_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved18</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39506100">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved19</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved19_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved19</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fa600">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39506c00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved20</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved20_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved20</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39507700">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved21</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved21_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved21</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39508200">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved22</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved22_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved22</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39508d00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved23_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fb100">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fbc00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fc700">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fd200">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fdd00">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved7_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394fe800">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved8_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394ff300">
                          <SHORT-NAME>ICBAD_10ms_Group01_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_10ms_Group01_Reserved9_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39483e00">
                          <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group07</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group07_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39486b00">
                          <SHORT-NAME>ICBAD_20ms_Group07_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group07_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39487a00">
                          <SHORT-NAME>ICBAD_20ms_Group07_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group07_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39460f00">
                          <SHORT-NAME>ICBAD_20ms_Group07_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group07_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d80400">
                          <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group09</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d8be00">
                          <SHORT-NAME>ICBAD_20ms_Group09_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d8e200">
                          <SHORT-NAME>ICBAD_20ms_Group09_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d90600">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d92a00">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d94e00">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d97200">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d99600">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb1d9ba00">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group09_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39370600">
                          <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group12</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39373300">
                          <SHORT-NAME>ICBAD_20ms_Group12_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39374200">
                          <SHORT-NAME>ICBAD_20ms_Group12_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39509800">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3950a300">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3950ae00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3950b900">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3950c400">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3950cf00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group12_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2847500">
                          <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2871a00">
                          <SHORT-NAME>ICBAD_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2874e00">
                          <SHORT-NAME>ICBAD_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb284aa00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb284de00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2851200">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2854600">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xNa505a3f19f34f4acdb2857a00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group13_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39499700">
                          <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group46</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group46_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394a1e00">
                          <SHORT-NAME>ICBAD_20ms_Group46_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group46_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b394a2d00">
                          <SHORT-NAME>ICBAD_20ms_Group46_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group46_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39465100">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group46_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39465c00">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group46_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39302300">
                          <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group48</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3930d700">
                          <SHORT-NAME>ICBAD_20ms_Group48_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3930e600">
                          <SHORT-NAME>ICBAD_20ms_Group48_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39303200">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39304100">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39305000">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39305f00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39306e00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39307d00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_20ms_Group48_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d1200">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_ZONE_10ms_Group20</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d9900">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391da800">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d2100">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d3000">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d3f00">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d4e00">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d5d00">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d6c00">
                          <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_10ms_Group20_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392fba00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_ZONE_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39300500">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39301400">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d7900">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d8400">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d8f00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393d9a00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393da500">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393db000">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/ICBAD_ZONE_20ms_Group13_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3931b800">
                          <SHORT-NAME>IMUTmp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IMUTmp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMUTmp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3931c700">
                          <SHORT-NAME>IMUseq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IMUseq_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMUseq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39449e00">
                          <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3940fa00">
                          <SHORT-NAME>IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group43</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3944ad00">
                          <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39461a00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39462500">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39463000">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39463b00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39464600">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group43_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3944bc00">
                          <SHORT-NAME>IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393fda00">
                          <SHORT-NAME>IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group60</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3944cc00">
                          <SHORT-NAME>IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39598500">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959e800">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved10_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959f300">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved11_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39599000">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959a600">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959b100">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959bc00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959c700">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved7_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959d200">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved8_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3959dd00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_20ms_Group60_Reserved9_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947d500">
                          <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group49</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947f300">
                          <SHORT-NAME>IPD_50ms_Group49_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_CRC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39480200">
                          <SHORT-NAME>IPD_50ms_Group49_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_RC_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39479300">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved1_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39479e00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved2_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947a900">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved3_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947b400">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved4_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947bf00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved5_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947ca00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_50ms_Group49_Reserved6_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e4d00">
                          <SHORT-NAME>IPD_NKI_CHCANFD_IPD_NKI_CHCANFD_IPD_NKI_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NKI_CHCANFD_IPD_NKI_CHCANFD_IPD_NKI_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391df300">
                          <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391db700">
                          <SHORT-NAME>IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391de400">
                          <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e3e00">
                          <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e1100">
                          <SHORT-NAME>IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e0200">
                          <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e2000">
                          <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391dc600">
                          <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391dd500">
                          <SHORT-NAME>IPD_NOI_CHCANFD_IPD_NOI_CHCANFD_IPD_NOI_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NOI_CHCANFD_IPD_NOI_CHCANFD_IPD_NOI_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391e2f00">
                          <SHORT-NAME>IPD_NWI_CHCANFD_IPD_NWI_CHCANFD_IPD_NWI_CHCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/IPD_NWI_CHCANFD_IPD_NWI_CHCANFD_IPD_NWI_CHCANFD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_CHCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3947e400">
                          <SHORT-NAME>KeepPwrRsnIPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/KeepPwrRsnIPD_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeepPwrRsnIPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39482f00">
                          <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSAFnInd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39309b00">
                          <SHORT-NAME>LDWLKALVsulznReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWLKALVsulznReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKALVsulznReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3930aa00">
                          <SHORT-NAME>LDWLKARVsulznReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWLKARVsulznReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKARVsulznReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39308c00">
                          <SHORT-NAME>LDWLKAVbnLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWLKAVbnLvlReq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAVbnLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392c1800">
                          <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWStsForEdr_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWStsForEdr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3930b900">
                          <SHORT-NAME>LDWSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWSysFltSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3930c800">
                          <SHORT-NAME>LDWSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDWSysSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391f3700">
                          <SHORT-NAME>LDrvnWhlRotlDircn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDircn_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDircn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391f4800">
                          <SHORT-NAME>LDrvnWhlRotlDircnSdslSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39396d00">
                          <SHORT-NAME>LDrvnWhlRotlDistPlsCtr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDistPlsCtr_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistPlsCtr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39398b00">
                          <SHORT-NAME>LDrvnWhlRotlDistTRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDistTRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39397c00">
                          <SHORT-NAME>LDrvnWhlRotlDistTmsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDistTmsp_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistTmsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39399a00">
                          <SHORT-NAME>LDrvnWhlRotlDistV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlDistV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3939a900">
                          <SHORT-NAME>LDrvnWhlRotlRstOcd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlRstOcd_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlRstOcd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b3939b800">
                          <SHORT-NAME>LDrvnWhlRotlSeqNum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LDrvnWhlRotlSeqNum_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlSeqNum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391cb800">
                          <SHORT-NAME>LKAReqAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAReqAng_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391cc700">
                          <SHORT-NAME>LKAReqAngSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAReqAngSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAngSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391cd600">
                          <SHORT-NAME>LKAReqToq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAReqToq_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391ce500">
                          <SHORT-NAME>LKAReqToqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAReqToqSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392fc900">
                          <SHORT-NAME>LKASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKASysFltSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b392fd800">
                          <SHORT-NAME>LKASysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKASysSts_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d7b00">
                          <SHORT-NAME>LKAToqReqValMax</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAToqReqValMax_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAToqReqValMax</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b391d8a00">
                          <SHORT-NAME>LKAToqReqValMin</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LKAToqReqValMin_IPD_CHCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAToqReqValMin</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39208b00">
                          <SHORT-NAME>LNonDrvnWhlRotlDircn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDircn_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDircn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b39201400">
                          <SHORT-NAME>LNonDrvnWhlRotlDircnSdslSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a3000">
                          <SHORT-NAME>LNonDrvnWhlRotlDistPC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDistPC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistPC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a3f00">
                          <SHORT-NAME>LNonDrvnWhlRotlDistT</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDistT_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistT</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a4e00">
                          <SHORT-NAME>LNonDrvnWhlRotlDistTRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDistTRC_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a5d00">
                          <SHORT-NAME>LNonDrvnWhlRotlDistV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_CHCANFD/LNonDrvnWhlRotlDistV_IPD_CHCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b393a6c00">
