Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcJamRngNav</SHORT-LABEL>
                  <VALUE>0xFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcJamRngNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcJamRngNav</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3233f6XOa505a3f19f25843c4b3233f500">
              <SHORT-NAME>ITrfcLghtFuctionSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Light_Fuction_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:IPD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcLghtFuctionSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtFuctionSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtFuctionSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324392XOa505a3f19f25843c4b32439100">
              <SHORT-NAME>ITrfcLghtFuctionSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Light Fuction Switch Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ZXD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcLghtFuctionSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtFuctionSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtFuctionSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323b55XOa505a3f19f25843c4b323b5400">
              <SHORT-NAME>ITrfcLghtStSp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Light Start/Stop Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcLghtStSp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtStSp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtStSp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323b93XOa505a3f19f25843c4b323b9200">
              <SHORT-NAME>ITrfcMrgdForbidDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Forbid_Sign_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯停止线距离
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdForbidDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdForbidDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdForbidDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323bb2XOa505a3f19f25843c4b323bb100">
              <SHORT-NAME>ITrfcMrgdForbidSign</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Forbid_Sign</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯停止线标识
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdForbidSign</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>64</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT64</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdForbidSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdForbidSign</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323c4dXOa505a3f19f25843c4b323c4c00">
              <SHORT-NAME>ITrfcMrgdInfoSign</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Information_Sign</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯信息标识
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdInfoSign</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>64</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT64</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdInfoSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdInfoSign</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32440eXOa505a3f19f25843c4b32440d00">
              <SHORT-NAME>ITrfcMrgdInfoSignDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Information_Sign_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯信息标识距离
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdInfoSignDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdInfoSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdInfoSignDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324563XOa505a3f19f25843c4b32456200">
              <SHORT-NAME>ITrfcMrgdWrnngSign</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Warnning_Sign</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯报警标识
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdWrnngSign</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>64</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT64</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdWrnngSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdWrnngSign</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3239c2XOa505a3f19f25843c4b3239c100">
              <SHORT-NAME>ITrfcMrgdWrnngSignDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Merged_Warnning_Sign_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:null
发送方描述:红绿灯报警标识距离
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcMrgdWrnngSignDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdWrnngSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdWrnngSignDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fa70XOa505a3f19f25843c4b37fa6f00">
              <SHORT-NAME>ITrgtCndSpdReqCamr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Condition Speed Request Camera</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:FVCM发送的条件限速值信号
接收方描述:SLIF系统输出的条件限速值
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:PICM 智能限速</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtCndSpdReqCamr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtCndSpdReqCamr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtCndSpdReqCamr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f119XOa505a3f19f25843c4b34f11800">
              <SHORT-NAME>ITrgtSOCReqAI</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Soc Request AI</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:AI能量管理
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSOCReqAI</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqAI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSOCReqAI</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f185XOa505a3f19f25843c4b34f18400">
              <SHORT-NAME>ITrgtSOCReqAIV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Soc Request AI Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:AI能量管理
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSOCReqAIV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqAIV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSOCReqAIV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e86b0XOa505a3f19f25843c4b2e86af00">
              <SHORT-NAME>ITrgtSOCReqFICM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Soc Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSOCReqFICM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSOCReqFICM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e86cfXOa505a3f19f25843c4b2e86ce00">
              <SHORT-NAME>ITrgtSOCReqFICMV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Soc Request Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSOCReqFICMV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSOCReqFICMV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f092XOa505a3f19f25843c4b34f09100">
              <SHORT-NAME>ITrgtSOCUpdtReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Soc Update Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:AI能量管理
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSOCUpdtReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCUpdtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSOCUpdtReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346452XOa505a3f19f25843c4b34645100">
              <SHORT-NAME>ITrgtSpdSrcSts_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Speed Source Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:SLIF限速来源
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrgtSpdSrcSts_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSpdSrcSts_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSpdSrcSts_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31b1bdXOa505a3f19f25843c4b31b1bc00">
              <SHORT-NAME>ITripCnt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Trip Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:Y
有无服务标签:
发送方描述:构成SecOC同步报文
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):0.0
Num. Of Repetition:0.0
Signal Type:UNM
备注:网络安全</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TripCnt</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TripCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TripCnt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31b1dcXOa505a3f19f25843c4b31b1db00">
              <SHORT-NAME>ITripCntResetReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Trip Counter Reset Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:行程计数器重置请求
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):0.0
Num. Of Repetition:0.0
Signal Type:ENM
备注:网络安全</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TripCntResetReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TripCntResetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TripCntResetReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c195XOa505a3f19f25843c4b37c19400">
              <SHORT-NAME>ITrlrCnctSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Trailer Connect Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:拖车自动模式连接状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrlrCnctSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrlrCnctSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrlrCnctSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bddbXOa505a3f19f25843c4b34bdda00">
              <SHORT-NAME>ITrlrMdSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_200ms_Group79
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrlrMdSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrlrMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrlrMdSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e870dXOa505a3f19f25843c4b2e870c00">
              <SHORT-NAME>IUSBHubPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">USBHub Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>USBHubPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/USBHubPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/USBHubPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369412XOa505a3f19f25843c4b36941100">
              <SHORT-NAME>IUsgMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Usage Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:使用模式,用户模式，用于记录快照
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，诊断,VS，外灯，CCEOP,尾门,EPS,SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>UsgMd</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/UsgMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369585XOa505a3f19f25843c4b36958400">
              <SHORT-NAME>IUsgMdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Usage Mode Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:valid,用户模式有效性，用于记录快照
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，诊断,VS，外灯，CCEOP,尾门,EPS,SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>UsgMdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/UsgMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368571XOa505a3f19f25843c4b36857000">
              <SHORT-NAME>IVCUAPAFltRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">VCU APA Fault Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VCUAPAFltRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUAPAFltRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUAPAFltRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b368590XOa505a3f19f25843c4b36858f00">
              <SHORT-NAME>IVCUAPAUnderCtrlA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">VCU APA Under Control Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VCUAPAUnderCtrlA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUAPAUnderCtrlA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUAPAUnderCtrlA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eb2abXOa505a3f19f25843c4b2eb2aa00">
              <SHORT-NAME>IVCUCtrlS2Req</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Control Unit Control S2 Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:S2控制指令
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VCUCtrlS2Req</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUCtrlS2Req</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUCtrlS2Req</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37f664XOa505a3f19f25843c4b37f66300">
              <SHORT-NAME>IVCU_ISAOvSpdOvRd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">VCU_Intelligence_Speed_Assist_Overspeed_Override</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group90
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ISA override状态位
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VCU_ISAOvSpdOvRd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCU_ISAOvSpdOvRd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCU_ISAOvSpdOvRd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec3b0XOa505a3f19f25843c4b2ec3af00">
              <SHORT-NAME>IVDCSlipCtrlSts_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">VDCSlipCtrlSts_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VDCSlipCtrlSts_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VDCSlipCtrlSts_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VDCSlipCtrlSts_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37bedcXOa505a3f19f25843c4b37bedb00">
              <SHORT-NAME>IVMCTarReWhlTqMaxLmt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Motion Control Target Rear Wheel Torque Maximum Limit</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VMCTarReWhlTqMaxLmt</SHORT-LABEL>
                  <VALUE>0x7FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VMCTarReWhlTqMaxLmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarReWhlTqMaxLmt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c3abXOa505a3f19f25843c4b37c3aa00">
              <SHORT-NAME>IVMCTarReWhlTqMaxLmtV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Motion Control Target Rear Wheel Torque  Maximum Limit Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:Y
信息安全:
有无服务标签:
发送方描述:RZCU
接收方描述:PICM/PEU
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:VMC扭矩请求值（后轴）最大限值以及有效性</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VMCTarReWhlTqMaxLmtV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VMCTarReWhlTqMaxLmtV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarReWhlTqMaxLmtV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37bef7XOa505a3f19f25843c4b37bef600">
              <SHORT-NAME>IVMCTarWhlTqMaxLmt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Motion Control Target Wheel Torque Maximum Limit</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VMCTarWhlTqMaxLmt</SHORT-LABEL>
                  <VALUE>0x7FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VMCTarWhlTqMaxLmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarWhlTqMaxLmt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37bf12XOa505a3f19f25843c4b37bf1100">
              <SHORT-NAME>IVMCTarWhlTqMaxLmtV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Motion Control Target Wheel Torque Maximum Limit Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group22
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VMCTarWhlTqMaxLmtV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VMCTarWhlTqMaxLmtV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarWhlTqMaxLmtV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36716bXOa505a3f19f25843c4b36716a00">
              <SHORT-NAME>IVSELatAccV_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Lateral Acceleration Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:valid,侧向加速度有效值
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSELatAccV_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSELatAccV_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELatAccV_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36714cXOa505a3f19f25843c4b36714b00">
              <SHORT-NAME>IVSELatAcc_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Lateral Acceleration</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:横向加速度,侧向加速度值
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSELatAcc_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSELatAcc_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELatAcc_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3671a9XOa505a3f19f25843c4b3671a800">
              <SHORT-NAME>IVSELongtAccV_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Longitudinal Acceleration Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:valid,纵向加速度有效值
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSELongtAccV_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSELongtAccV_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELongtAccV_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36718aXOa505a3f19f25843c4b36718900">
              <SHORT-NAME>IVSELongtAcc_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Longitudinal Acceleration</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:纵向加速度
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSELongtAcc_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSELongtAcc_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELongtAcc_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3660f0XOa505a3f19f25843c4b3660ef00">
              <SHORT-NAME>IVSEMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:稳定性控制系统控制状态,ESP模式
接收方描述:EDR元素，车身稳定系统,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSEMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSEMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSEMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36610fXOa505a3f19f25843c4b36610e00">
              <SHORT-NAME>IVSESts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:VSE故障状态,ESP功能状态
接收方描述:EDR元素，车身稳定系统,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSESts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSESts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36612eXOa505a3f19f25843c4b36612d00">
              <SHORT-NAME>IVSESysA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Stability Enhancement System Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:稳定性控制系统激活状态,ESP激活状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VSESysA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VSESysA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESysA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbb6d9XNa505a3f19f34f4acdbbb6ca00">
              <SHORT-NAME>IVdop</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vertical Dilution Of Precision</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:IAM_ZONE_100ms_Group34
功能安全:
信息安全:
有无服务标签:
发送方描述:垂直分量精度因子
接收方描述:IPD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>Vdop</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Vdop</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Vdop</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375913XOa505a3f19f25843c4b37591200">
              <SHORT-NAME>IVehBkwdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Backward Switch Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehBkwdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehBkwdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37592eXOa505a3f19f25843c4b37592d00">
              <SHORT-NAME>IVehBkwdSwReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Backward Switch Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehBkwdSwReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehBkwdSwReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e71fcXOa505a3f19f25843c4b2e71fb00">
              <SHORT-NAME>IVehCrshTyp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Crash Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:车辆碰撞状态
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，外灯,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehCrshTyp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehCrshTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehCrshTyp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369d32XOa505a3f19f25843c4b369d3100">
              <SHORT-NAME>IVehDrvngMd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group80
功能安全:E2E
信息安全:
有无服务标签:
发送方描述:驾驶模式状态信号
接收方描述:驾驶模式状态信号
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehDrvngMd</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehDrvngMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDrvngMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36712dXOa505a3f19f25843c4b36712c00">
              <SHORT-NAME>IVehDynYawRateV_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Dynamics Yaw Rate Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:横摆角速度有效值
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehDynYawRateV_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehDynYawRateV_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDynYawRateV_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36710eXOa505a3f19f25843c4b36710d00">
              <SHORT-NAME>IVehDynYawRate_SDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Dynamics Yaw Rate</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:ASIL-B,ASIL B,ASILB
信息安全:
有无服务标签:
发送方描述:横摆角速度
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:EPS,SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehDynYawRate_SDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehDynYawRate_SDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDynYawRate_SDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbea44XNa505a3f19f34f4acdbbea3500">
              <SHORT-NAME>IVehEnrgRdyLvl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Energy_Ready_Level</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group19
功能安全:
信息安全:
有无服务标签:
发送方描述:整车低压能耗等级
接收方描述:Tester,IAM
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:驻车能耗&amp;电源管理，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehEnrgRdyLvl</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehEnrgRdyLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbea6dXNa505a3f19f34f4acdbbea5e00">
              <SHORT-NAME>IVehEnrgRdyLvlV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Energy_Ready_Level_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group19
功能安全:
信息安全:
有无服务标签:
发送方描述:整车低压能耗等级
接收方描述:Tester,IAM
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:驻车能耗&amp;电源管理，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehEnrgRdyLvlV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehEnrgRdyLvlV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvlV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375949XOa505a3f19f25843c4b37594800">
              <SHORT-NAME>IVehFwdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Forward Switch Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehFwdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehFwdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375964XOa505a3f19f25843c4b37596300">
              <SHORT-NAME>IVehFwdSwReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Forward Switch Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehFwdSwReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehFwdSwReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b51eXOa505a3f19f25843c4b37b51d00">
              <SHORT-NAME>IVehHzrdMdSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Hazard_Mode_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:ASIL
信息安全:
有无服务标签:
发送方描述:整车危险模式状态
接收方描述:整车危险模式状态
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehHzrdMdSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehHzrdMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehHzrdMdSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b539XOa505a3f19f25843c4b37b53800">
              <SHORT-NAME>IVehIlluminateCtrlCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Illuminate Control Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:整车背光灯点亮熄灭
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:内灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehIlluminateCtrlCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehIlluminateCtrlCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehIlluminateCtrlCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3630XOa505a3f19f25843c4b2e362f00">
              <SHORT-NAME>IVehLckSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Lock Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:门锁信号，门锁状态发布功能
接收方描述:LckngCtrlMdl
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，电动窗，音响,尾门,SDM,IBS,AC，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehLckSts</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehLckSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehLckSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369d4eXOa505a3f19f25843c4b369d4d00">
              <SHORT-NAME>IVehLdShedLvl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Load_Shed_Level</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group80
功能安全:
信息安全:
有无服务标签:
发送方描述:低压负载等级限值
接收方描述:PICU
LHZCU
RHZCU
ESS
PEU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:驻车能耗&amp;电源管理，ESS,EPS,SDM,IBS，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehLdShedLvl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehLdShedLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehLdShedLvl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3695a3XOa505a3f19f25843c4b3695a200">
              <SHORT-NAME>IVehMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:车辆模式,车辆模式，用于记录快照,整车模式
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:门锁，诊断,VS，外灯，CCEOP,尾门,SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3695c2XOa505a3f19f25843c4b3695c100">
              <SHORT-NAME>IVehMdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Mode Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:valid,车辆模式有效性，用于记录快照
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:门锁，诊断,VS，外灯，CCEOP,尾门,SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehMdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369d6dXOa505a3f19f25843c4b369d6c00">
              <SHORT-NAME>IVehOdo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Odometer</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group80
功能安全:
信息安全:
有无服务标签:
发送方描述:续驶里程,行驶里程，用于记录快照,总计里程,ICB总里程发布,整车ODO，IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:电动窗，外灯，HMI，CCEOP,ESS,CCU,EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehOdo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehOdo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369d8cXOa505a3f19f25843c4b369d8b00">
              <SHORT-NAME>IVehOdoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Odometer_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group80
功能安全:
信息安全:
有无服务标签:
发送方描述:续驶里程Valid,行驶里程有效性，用于记录快照,总计里程,ICB总里程发布有效位,整车ODO，IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗，外灯，HMI，CCEOP,ESS,CCU,EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehOdoV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehOdoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e46b5XOa505a3f19f25843c4b2e46b400">
              <SHORT-NAME>IVehRfulSta</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Refuel State</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:QM
信息安全:
有无服务标签:
发送方描述:用于发给娱乐屏加油状态描述
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:加油管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehRfulSta</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehRfulSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRfulSta</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37597fXOa505a3f19f25843c4b37597e00">
              <SHORT-NAME>IVehRoadWhlLReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Road Wheel Left Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehRoadWhlLReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehRoadWhlLReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37599aXOa505a3f19f25843c4b37599900">
              <SHORT-NAME>IVehRoadWhlLReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Road Wheel Left Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehRoadWhlLReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehRoadWhlLReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3759b5XOa505a3f19f25843c4b3759b400">
              <SHORT-NAME>IVehRoadWhlRReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Road Wheel Right Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehRoadWhlRReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehRoadWhlRReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3759d0XOa505a3f19f25843c4b3759cf00">
              <SHORT-NAME>IVehRoadWhlRReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Road Wheel Right Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehRoadWhlRReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehRoadWhlRReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366982XOa505a3f19f25843c4b36698100">
              <SHORT-NAME>IVehSdslSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Standstill Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:整车standstill状态
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSdslSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3669a1XOa505a3f19f25843c4b3669a000">
              <SHORT-NAME>IVehSdslStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Standstill Status Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:车辆standstill状态,整车standstill状态
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSdslStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSdslStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b554XOa505a3f19f25843c4b37b55300">
              <SHORT-NAME>IVehSideLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Side Light Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSideLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSideLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSideLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c1b1XOa505a3f19f25843c4b37c1b000">
              <SHORT-NAME>IVehSideLghtSts_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Side Light Status_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光故障状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSideLghtSts_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSideLghtSts_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSideLghtSts_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3664d3XOa505a3f19f25843c4b3664d200">
              <SHORT-NAME>IVehSpdAvg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Speed_Average</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL A,ASILB,NA,Y/ASIL B
信息安全:
有无服务标签:
发送方描述:平均车速
接收方描述:用于随速补偿,LHZCU,ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:门锁，雨刮洗涤，外灯,尾门，ESS,EPS,SDM,IBS,AC，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3664f2XOa505a3f19f25843c4b3664f100">
              <SHORT-NAME>IVehSpdAvgDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Speed Average Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL-D,ASIL A,Y,ASIL B,ASILB
信息安全:YES
有无服务标签:
发送方描述:车速，用于记录快照及诊断服务先决条件判断
接收方描述:车辆平均车速,EDR车速信号,驱动轮车速信号,用于AVAS音效算法/ICB,ICBAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:诊断，音响，外灯，HMI，CCEOP，ESS,CCU,EPS,SDM,IBS,AC,PICU，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366511XOa505a3f19f25843c4b36651000">
              <SHORT-NAME>IVehSpdAvgDrvnSrc</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Speed Average Driven Source</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL A,ASILB
信息安全:
有无服务标签:
发送方描述:
接收方描述:平均车速来源
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:ESS,EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgDrvnSrc</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgDrvnSrc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnSrc</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366530XOa505a3f19f25843c4b36652f00">
              <SHORT-NAME>IVehSpdAvgDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Speed Average Driven Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL-D,ASIL A,Y,ASIL B,ASILB
信息安全:YES
有无服务标签:
发送方描述:车速有效性，用于记录快照及诊断服务先决条件判断
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:诊断，音响，外灯，HMI，CCEOP，ESS,CCU,EPS,SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgDrvnV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36654fXOa505a3f19f25843c4b36654e00">
              <SHORT-NAME>IVehSpdAvgNonDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Speed Average Non Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL-D,ASIL A,ASILB
信息安全:YES
有无服务标签:
发送方描述:前轮车速,非驱动轮车速,非驾驶车辆平均车速
接收方描述:ZXDAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgNonDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgNonDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36656eXOa505a3f19f25843c4b36656d00">
              <SHORT-NAME>IVehSpdAvgNonDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Speed Average Non Driven Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL-D,ASIL A,ASILB
信息安全:YES
有无服务标签:
发送方描述:前轮车速Valid,非驱动轮车速,车辆平均速度非驱动有效性,非驱动轮车速有效性
接收方描述:ZXDAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgNonDrvnV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgNonDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36658dXOa505a3f19f25843c4b36658c00">
              <SHORT-NAME>IVehSpdAvgV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle_Speed_Average_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group11
功能安全:ASIL A,ASILB,Y/ASIL B
信息安全:
有无服务标签:
发送方描述:平均车速有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，雨刮洗涤,尾门,ESS,EPS,SDM,IBS,AC，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehSpdAvgV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehSpdAvgV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e872cXOa505a3f19f25843c4b2e872b00">
              <SHORT-NAME>IVehTiPblshDay</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Day</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshDay</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshDay</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshDay</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e874bXOa505a3f19f25843c4b2e874a00">
              <SHORT-NAME>IVehTiPblshHr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Hour</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshHr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshHr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshHr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e876aXOa505a3f19f25843c4b2e876900">
              <SHORT-NAME>IVehTiPblshMins</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Minute</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshMins</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshMins</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshMins</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8789XOa505a3f19f25843c4b2e878800">
              <SHORT-NAME>IVehTiPblshMth</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Month</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshMth</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshMth</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshMth</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e87a8XOa505a3f19f25843c4b2e87a700">
              <SHORT-NAME>IVehTiPblshSec</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Second</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshSec</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshSec</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshSec</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e87c7XOa505a3f19f25843c4b2e87c600">
              <SHORT-NAME>IVehTiPblshYear</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle Time Publish Year</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:整车时间发布
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:时间管理，诊断，CCEOP,ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehTiPblshYear</SHORT-LABEL>
                  <VALUE>0x13</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehTiPblshYear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshYear</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b06aXOa505a3f19f25843c4b37b06900">
              <SHORT-NAME>IVehboardSetting</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Vehicle dashboard Setting</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VehboardSetting</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VehboardSetting</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehboardSetting</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318d26XOa505a3f19f25843c4b318d2500">
              <SHORT-NAME>IVeldownsigma</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Veldownsigma</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:地向速度sigma值
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>Veldownsigma</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Veldownsigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Veldownsigma</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3181c4XOa505a3f19f25843c4b3181c300">
              <SHORT-NAME>IVeleastsigma</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Veleastsigma</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:东向速度sigma值
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>Veleastsigma</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Veleastsigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Veleastsigma</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318984XOa505a3f19f25843c4b31898300">
              <SHORT-NAME>IVelnorthsigma</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Velnorthsigma</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:北向速度sigma值
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>Velnorthsigma</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Velnorthsigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Velnorthsigma</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34a0d3XOa505a3f19f25843c4b34a0d200">
              <SHORT-NAME>IVolmcSnsrSetngReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Volumetric Sensor Setting Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:立体警戒设置请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>VolmcSnsrSetngReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VolmcSnsrSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VolmcSnsrSetngReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cd26XOa505a3f19f25843c4b37cd2500">
              <SHORT-NAME>IWCACThrWayVlvActuPos</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Water Charger Air Cooler Three Way Valve Actual Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:WCAC三通阀实际位置
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WCACThrWayVlvActuPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WCACThrWayVlvActuPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WCACThrWayVlvActuPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cd0bXOa505a3f19f25843c4b37cd0a00">
              <SHORT-NAME>IWCACThrWayVlvActuPosV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Water Charger Air Cooler Three Way Valve Actual Position Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:WCAC三通阀实际位置
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WCACThrWayVlvActuPosV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WCACThrWayVlvActuPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WCACThrWayVlvActuPosV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3669c0XOa505a3f19f25843c4b3669bf00">
              <SHORT-NAME>IWhlBrkPrsSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel Brake Pressure Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:轮缸制动压力状态
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlBrkPrsSts</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlBrkPrsSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlBrkPrsSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36640aXOa505a3f19f25843c4b36640900">
              <SHORT-NAME>IWhlGndVelLDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Left_Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group09
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:左侧驱动轮轮速信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelLDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelLDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36642aXOa505a3f19f25843c4b36642900">
              <SHORT-NAME>IWhlGndVelLDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Left_Driven_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group09
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:左侧驱动轮轮速有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelLDrvnV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelLDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366658XOa505a3f19f25843c4b36665700">
              <SHORT-NAME>IWhlGndVelLNonDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Left_Non_Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:左侧非驱动轮轮速
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelLNonDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelLNonDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366678XOa505a3f19f25843c4b36667700">
              <SHORT-NAME>IWhlGndVelLNonDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Left_Non_Driven_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:左侧非驱动轮轮速有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelLNonDrvnV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelLNonDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36644aXOa505a3f19f25843c4b36644900">
              <SHORT-NAME>IWhlGndVelRDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Right_Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group09
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:右侧驱动轮轮速信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelRDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelRDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36646aXOa505a3f19f25843c4b36646900">
              <SHORT-NAME>IWhlGndVelRDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Right_Driven_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group09
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:右侧驱动轮轮速有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelRDrvnV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelRDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366698XOa505a3f19f25843c4b36669700">
              <SHORT-NAME>IWhlGndVelRNonDrvn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Right_Non_Driven</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL-B,ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:右侧非驱动轮轮速
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelRNonDrvn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelRNonDrvn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3666b8XOa505a3f19f25843c4b3666b700">
              <SHORT-NAME>IWhlGndVelRNonDrvnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel_Ground_Velocity_Right_Non_Driven_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group12
功能安全:ASIL A,ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:右侧非驱动轮轮速有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，EPS,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlGndVelRNonDrvnV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlGndVelRNonDrvnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2542XOa505a3f19f25843c4b2e254100">
              <SHORT-NAME>IWhlRghRoad</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel Rough Road</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:轮加速度
接收方描述:PICU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlRghRoad</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlRghRoad</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlRghRoad</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2561XOa505a3f19f25843c4b2e256000">
              <SHORT-NAME>IWhlRghRoadV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Wheel Rough Road Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:轮加速度有效性
接收方描述:PICU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WhlRghRoadV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WhlRghRoadV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlRghRoadV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b349c52XOa505a3f19f25843c4b349c5100">
              <SHORT-NAME>IWlcmLghtReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Welcome Light Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:迎宾请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WlcmLghtReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WlcmLghtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WlcmLghtReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3467b4XOa505a3f19f25843c4b3467b300">
              <SHORT-NAME>IWlcmLghtReq_LHZCU</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Welcome Light Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:迎宾请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WlcmLghtReq_LHZCU</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WlcmLghtReq_LHZCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WlcmLghtReq_LHZCU</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37a215XOa505a3f19f25843c4b37a21400">
              <SHORT-NAME>IWlcmReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Welcome Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:迎宾模式触发
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>WlcmReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/WlcmReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WlcmReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37f96aXOa505a3f19f25843c4b37f96900">
              <SHORT-NAME>IYawnStatus_IMM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Yawn Status_IMM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IMM_50ms_Group02
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:哈欠状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>YawnStatus_IMM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/YawnStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/YawnStatus_IMM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ae6aXOa505a3f19f25843c4b37ae6900">
              <SHORT-NAME>IZXDSkndReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_shakehand_request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZXD握手请求信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):100.0
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXDSkndReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXDSkndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXDSkndReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b230XOa505a3f19f25843c4b36b22f00">
              <SHORT-NAME>IZXD_NKI_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD BKPCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NKI_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NKI_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b83bXOa505a3f19f25843c4b36b83a00">
              <SHORT-NAME>IZXD_NKI_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD CHCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NKI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NKI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a74dXOa505a3f19f25843c4b36a74c00">
              <SHORT-NAME>IZXD_NKI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD RZCUCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NKI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NKI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b05fXOa505a3f19f25843c4b36b05e00">
              <SHORT-NAME>IZXD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_BSMtoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_BSMtoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_BSMtoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36aa53XOa505a3f19f25843c4b36aa5200">
              <SHORT-NAME>IZXD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_BSMtoRMS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_BSMtoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_BSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b0dbXOa505a3f19f25843c4b36b0da00">
              <SHORT-NAME>IZXD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_BSMtoRMS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_BSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_BSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a8feXOa505a3f19f25843c4b36a8fd00">
              <SHORT-NAME>IZXD_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOSSta_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOSSta_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a7aaXOa505a3f19f25843c4b36a7a900">
              <SHORT-NAME>IZXD_NM_NOSSta_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOSSta_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOSSta_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOSSta_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b1d3XOa505a3f19f25843c4b36b1d200">
              <SHORT-NAME>IZXD_NM_NOSSta_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOSSta_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b4daXOa505a3f19f25843c4b36b4d900">
              <SHORT-NAME>IZXD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOStoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOStoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ad3aXOa505a3f19f25843c4b36ad3900">
              <SHORT-NAME>IZXD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOStoRMS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOStoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36af86XOa505a3f19f25843c4b36af8500">
              <SHORT-NAME>IZXD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_NOStoRMS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_NOStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_NOStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a6d1XOa505a3f19f25843c4b36a6d000">
              <SHORT-NAME>IZXD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_PBSMtoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_PBSMtoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_PBSMtoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a91dXOa505a3f19f25843c4b36a91c00">
              <SHORT-NAME>IZXD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_PBSMtoRMS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_PBSMtoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_PBSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b81cXOa505a3f19f25843c4b36b81b00">
              <SHORT-NAME>IZXD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_PBSMtoRMS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_PBSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_PBSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36af48XOa505a3f19f25843c4b36af4700">
              <SHORT-NAME>IZXD_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMSSta_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMSSta_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ac23XOa505a3f19f25843c4b36ac2200">
              <SHORT-NAME>IZXD_NM_RMSSta_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMSSta_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMSSta_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMSSta_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36aab0XOa505a3f19f25843c4b36aaaf00">
              <SHORT-NAME>IZXD_NM_RMSSta_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMSSta_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ad1bXOa505a3f19f25843c4b36ad1a00">
              <SHORT-NAME>IZXD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMStoNOS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMStoNOS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b66cXOa505a3f19f25843c4b36b66b00">
              <SHORT-NAME>IZXD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMStoNOS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMStoNOS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36add5XOa505a3f19f25843c4b36add400">
              <SHORT-NAME>IZXD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RMStoNOS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RMStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RMStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a93cXOa505a3f19f25843c4b36a93b00">
              <SHORT-NAME>IZXD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoNOS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoNOS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b157XOa505a3f19f25843c4b36b15600">
              <SHORT-NAME>IZXD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoNOS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoNOS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b7bfXOa505a3f19f25843c4b36b7be00">
              <SHORT-NAME>IZXD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoNOS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36aeebXOa505a3f19f25843c4b36aeea00">
              <SHORT-NAME>IZXD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoRMS_BKPCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoRMS_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a76cXOa505a3f19f25843c4b36a76b00">
              <SHORT-NAME>IZXD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoRMS_CHCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoRMS_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a78bXOa505a3f19f25843c4b36a78a00">
              <SHORT-NAME>IZXD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD_NM_RSStoRMS_PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NM_RSStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NM_RSStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ab89XOa505a3f19f25843c4b36ab8800">
              <SHORT-NAME>IZXD_NOI_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD BKPCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NOI_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NOI_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ab6aXOa505a3f19f25843c4b36ab6900">
              <SHORT-NAME>IZXD_NOI_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD CHCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NOI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NOI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b3e2XOa505a3f19f25843c4b36b3e100">
              <SHORT-NAME>IZXD_NOI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD RZCUCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NOI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NOI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36ac42XOa505a3f19f25843c4b36ac4100">
              <SHORT-NAME>IZXD_NWI_BKPCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD BKPCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NWI_BKPCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NWI_BKPCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a8a2XOa505a3f19f25843c4b36a8a100">
              <SHORT-NAME>IZXD_NWI_CHCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD CHCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NWI_CHCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NWI_CHCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b556XOa505a3f19f25843c4b36b55500">
              <SHORT-NAME>IZXD_NWI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ZXD RZCUCANFD Network_Wakeup_Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZXD_NWI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZXD_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZXD_NWI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e366dXOa505a3f19f25843c4b2e366c00">
              <SHORT-NAME>IZoneFLSideLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Zone Front Left  Side Light State</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:位置灯硬线驱动状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZoneFLSideLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZoneFLSideLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZoneFLSideLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e368cXOa505a3f19f25843c4b2e368b00">
              <SHORT-NAME>IZoneRLSideLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Zone Rear Left Side Light State</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:位置灯硬线驱动状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ZoneRLSideLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ZoneRLSideLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ZoneRLSideLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4cd5c2f317a83cc8833469268a5f9fdd">
          <SHORT-NAME>SystemSignalGroups</SHORT-NAME>
          <ELEMENTS>
            <SYSTEM-SIGNAL-GROUP UUID="8f31a250132f38f2935268224312a2f0">
              <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCTem</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCHVILSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCHVILStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrHVILStsVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrHVILStsValV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDUHVILSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDUHVILStsV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="38bcb38973d83c56a62a0133a98a8712">
              <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUActiveWkup</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrMaxChrgPwr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrSpRsn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrAltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrAltrCrntInptVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrCtrlPilotPWMDuty</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrCtrlPilotPWMSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL1AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL1AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL2AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL2AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL3AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL3AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrLastWkup</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrOtptVolV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrWkup</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrAltrCrntInptHVCrntLmt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOpngMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptCrntV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptCrntVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptVolVal</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="0356777ad0ca36bf93bf94d12edb74f1">
              <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUClntFlowReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrSktEleccLckEnable</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved14</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSPTCHVILSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSPTCHVILStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCClntPumpPWMReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCHdwrFlr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCIntnlFlr</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="69db99d0eaa137db93670e3954d7dfd8">
              <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClOpenReqA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_Reserved39</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnActuStdyStaToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnActuStdyStaToqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnCCMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnCtrlrRunCrkTrmlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnRunA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpReqToTr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpdSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnTestMdEnbReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IntlckRelayAuth</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtCrkAbotd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtRunAbotd</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="b363e57e4a723a15a15a2eddbfbe4bb5">
              <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircnF</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvlnToqStabSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCustSetngDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEnASSOvrd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClStsV_ICE</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClSts_ICE</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrMinVolReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrRngInhSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrWrnngDsp</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="b263a403f64d3c228f561aacbec1e734">
              <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbs</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsOBD</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnClntTem</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnClntTemV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIntkAirTem</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIntkAirTemV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnWarmUpCycAch</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstdMsk</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrClThrmlProtnNotfn_ECM</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="b5feec057e233f7c98d37f73cf9f7eb4">
              <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_020ms_PDU03_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_020ms_PDU03_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_020ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_020ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSFrngDet</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSFuelReqdOn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSStallDet</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnAutoSpNotProb</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqActuExtdRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqActuExtdRngV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqDrvrReqdExtdRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqDrvrReqdExtdRngV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqRducnFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PropSysA</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="fb369345e9bb37d78f84507851185e16">
              <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECODrvngSpdRutA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngAIO</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngDspStsGearShftIndSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngDspStsRcmndFwdGear</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMaxExtdRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMaxExtdRngV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMinExtdRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMinExtdRngV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="b0a3fbefd49b35fb9ac74b4b81d730cf">
              <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqTorResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqTorRespV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESStsInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCAngRespSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCCodrivingSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCRespStsInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="ceb0e234cebd337d9dd11394bb7078e9">
              <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAngV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CHLKAHptResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChLKAAngReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChLKAToqReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrStrgDlvrdToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrStrgDlvrdToqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSActRetMotToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSActRetMotToqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSCoDrivingSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSCurntDrvMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSDrvngMdCtrlInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSLimMotToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSLimMotToqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSPriyChnlFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMax</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMaxV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMin</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMinV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgCustSetngDspCmd</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="1ab7f5c7f99636f2b209a718f37fcc1e">
              <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPkgAngReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPkgAngReqRespInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAngRespSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAngRespStsInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAvlLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltCtrlChannel</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="5779eaf8cb863e54bc473ff919946d5e">
              <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngGrd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrCalSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrFlt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrInid</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrMultCapb</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="507f060e4fa93bbe83568748390eb40b">
              <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAPAInh</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAPASts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved5</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="b302f7f917673ba6a55528fb28901806">
              <SHORT-NAME>ESS_100ms_Group25</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSNegPtIsltnRstc</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSNegPtIsltnRstcV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSPosPtIsltnRstc</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSPosPtIsltnRstcV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group25_Reserved4</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="c95db0f685363461930d46e5942eac32">
              <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVolV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved7</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="8481b7c8607c340c9742e54e5aea6ad6">
              <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDRSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="7577a6d9f1dd33599645a2b85c3007bc">
              <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqAngSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqToq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqToqSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="6e338c990b08321298d24f0be2da59d8">
              <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjDistLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDrvrSelTrgtSpd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoNotfr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCMsgReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSeldTrgtDistLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTJAMdSwDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKSysSts_IPD</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOffRoadDetnSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOffRoadDetnStaV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HandOffStrgWhlDetnSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HandOffStrgWhlDetnStaV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCActvnDircnDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCActvnVelDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCSwDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWAdoWrnngDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAAudReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKADspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAHptWrnngDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSnstvtLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKADrvrTkovReq</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="2690b781a9ce3344afdbafac46719dbc">
              <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltSigma</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LatSigma</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LonSigma</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="18e59e38884d3474bd0e987c05c4cfdd">
              <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HeadingSigma</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PitchRTK</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PitchSigma</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="17054d34d010386e90ca5addbfa857a9">
              <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_GNSS_Signal_Status</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LatitudeRTK</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="58c258377d173839a6b82b327d76ac5d">
              <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtDrvrTrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstAbotBtnSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstBtnSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcFlrRsn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstParkngOutDircnSeln</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReqV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="8d05dee3cbaa3741ab5c503ed7bba3a4">
              <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FixType</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSSeq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSUTCTimeH</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_Reserved13</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="de37f092556f3c25b3cc727555e62e8c">
              <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Hdop</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved23</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved39</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved55</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Pdop</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Vdop</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="9abc3c1d912431ba8b6b15f4d6b77234">
              <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSF9HCounter</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSUTCTime</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_Reserved15</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="90b5df54f51939a9bdf6a3974542603e">
              <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltitudeRTK</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HeadingRTK</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_Reserved63</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="42d9a9b852bb31c9ab9a2796862b8be8">
              <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LongitudeRTK</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="c33c423c221c320c851c004558db52b5">
              <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFltAlrm_GB</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFrc_GB</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CsbLvlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnRstOcd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnSrc</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSABSlvlResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSESPlvlResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSTCSlvlResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved6</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="5ce48d973d803353a0ac5b28a3568257">
              <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistPlsCtr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistTmsp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistPlsCtr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistTmsp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="83127aa870083893837d67fdc3befc24">
              <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistPC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistT</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistPC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistT</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="f8af1534ab01394b81c7c8450aa0d9b3">
              <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPosV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysBrkLghtsReqd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysEnToqReqProtn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysBrkLghtsReqdA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved6</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="7267dc0d94283ecb86e22ad219975b3c">
              <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSF</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSIO</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVHSigPdlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMdSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMsg</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstAvlbl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRedBrkTlltReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysYlwBrkTlltReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EBDA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EBDFaultSt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkAV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnDragToqRducnA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HBAActiveSt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HBAValidSt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HDCSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group07_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MSRA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MSRF</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MulColBrkA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MulColBrkAvlblySts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MultColBrkEnbA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SoftSpSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSEnbd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSEMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESysA</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="89dfb9531a963eff8575288f567c8cee">
              <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysSecyBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysSecyBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTrBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTrBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAPAAvlbl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAppcnSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAvlblySts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBCCCanclReqd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSwSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSwStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysAudWrnngReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysDspMsgReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysStsIndReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysWrnngIndReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group08_RC</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="834664a1e5523028a0e8b6ba4fb25ded">
              <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTotBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTotBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvnV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="03d4e132bb263f26b5db6ca54a5a61b2">
              <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkDiscTemSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLow</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLowV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrs</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDet</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDetV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlActSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrs</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqOtptRodTrvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqOtptRodTrvlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="52785a1285ff34259cd8d27df073aaab">
              <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvg</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnSrc</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="7d86254a96a13b6db9319fe92e4adb21">
              <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvnV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvnV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="cf20f5c45f8f350196d6130409825edc">
              <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCBrkngA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqRespV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRddySysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChACCAccReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChACCReqFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBBrkJerkReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBDclReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBHydBrkAstReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBPrflReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChEBADclReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChRCTBDclReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChRCTBPrflReqResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkReqdByIECUSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ExtnlBrkPrio</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ExtnlBrkPrioV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSAPASysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MultColBrkAvlblySts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclAV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldAV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSDrvrItnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlBrkPrsSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="513581cd0d7f3533ab6c4ffcfd9c7446">
              <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkBstFnSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAppcnSts_M</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSRespAccToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved5</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="087c7070f3eb3f14bcc2ed149d37328f">
              <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved103</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved111</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved119</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved127</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved135</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved143</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved151</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved159</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved167</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved175</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved183</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved191</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved23</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved31</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved39</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved47</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved55</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved71</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved79</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved87</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved95</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSlntPtrlEnbSwResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSwResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBSysFltSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="67f8e8a6d32a3469bdea49f24ac154c8">
              <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngMsgReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSetResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSwDspCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DILampsCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HzrdLampsCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved8</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="7cd09412aabf3044bf3dff50410b9940">
              <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqAppdCoefnt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved14</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved16</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved17</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved18</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved19</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved20</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved21</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved22</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved23</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PltEPSRdWhlAngReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PltEPSRdWhlAngReqStsV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="2543ad8e7c31308dba62714d0099b01a">
              <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACrpSpdReqVal_IPD</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APARevrDrgReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATotWhlToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVCUReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved14</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved9</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="f22bdcb2c8f73b588379f7afaa103446">
              <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqSts_CH</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSdslReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPkgAPASCSAcclReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSAcclReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_Reserved1</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="47585a83ff2d3a1cb2fa5e861b433322">
              <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSABacSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSADisFucSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSAForSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSAReqAVMDis</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="3e0e2a17a8bd34e48af4cca3eb4a6123">
              <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_Reserved6</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="738a4d42a18236d687a8defb560f8318">
              <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACmdEPSSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAF</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqStsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="bb198edfbb0b3622a5e199db1733074f">
              <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDclReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsPT</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group15_Reserved9</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="1d0f85c8ce5b3ca7a46540e2c522a225">
              <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBBrkJerkLvlReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBHydBrkAstLvlReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBPrflReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group46_Reserved2</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="f86b830ce4dd347a8c6da84fe7689d14">
              <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group48_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKALVsulznReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKARVsulznReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAVbnLvlReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSysSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="94a92f93e6be34fe88bb1afc1eea1e07">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_10ms_Group20_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAToqReqValMax</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAToqReqValMin</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="1bd0442edc663994bc94f7a6813101ab">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_ZONE_20ms_Group13_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKASysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKASysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="1c246eb28bd3365490b1fd253f710b18">
              <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClstrDspdVehSpd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DspMeasmtSys</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatHeatCtrlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatVentCtrlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatHeatCtrlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSeatVentCtrlSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved103</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved111</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved119</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved127</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved14</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved21</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved31</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved47</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved55</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved71</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved72</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved79</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved80</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved84</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group01_Reserved92</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MdOfPwrMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDCSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdExtrCtrlAvlbl</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="81f6ce99e735383781d545986aa5c37f">
              <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AuxBatUnAssembled</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMCurEstdCapct</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMMaxEstdCapct</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPMOprtMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTToqCustSetngReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTToqCustSetngReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReqRaw</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnrgSplReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved21</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved35</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group19_Reserved58</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBMDisChrgMOSCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatChrgReqInhbt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatChrgReqRaw</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatEnrgLow</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatEnrgSufct</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LVBatSelfWakeupFlg</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PMDCSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICMV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehEnrgRdyLvlV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="390440b75c10364086c07a429a07b698">
              <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagSwStsReqV_Sfty</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagSwStsReq_Sfty</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_100ms_Group80_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDrvngMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehLdShedLvl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdo</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehOdoV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="538bdf588332390389db348181304a36">
              <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClstrDspdAirbagWrnng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTNotReadyReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_200ms_Group79_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OdoPriyPrcs</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OdoPriyPrcsV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrlrMdSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="ed77ec9ab3a43df4a2c5099d159d9c1b">
              <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AMRPrtensonReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BPMMstrAvlbly</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdMstrAccryA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdMstrRunCrkA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysOpnlMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVol</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/UsgMdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehMdV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="275ebf5bbaaf31819db2f655d6503012">
              <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCanclSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistDecSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistIncSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsOnSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsRsmSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdDecSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdIncSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSwDataIntgty</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HMISafFltsts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group11_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnEnbSwSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnSecySwSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PfTrTapUpDwnSwSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelDwnSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelUpSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlTipcSwDataIntgty</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SwStaE2EErr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw1A</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw2A</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw3A</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw4A</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="bb7d870691173beb89be6857cc032e50">
              <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocParkngSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrSsdManuCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved14</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved16</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group13_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMATESysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrMdCtrlResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdFICM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TgtParkingChosed</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="a42af9b07faa3b1096e90b344f7813c2">
              <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisAdjtVcCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmdSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCCASwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSetSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved13</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group158_Reserved9</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="f5f28104106b3d099904aab51a4e2085">
              <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DMSSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved100</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved103</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved111</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved119</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved127</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved85</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved95</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBVC_50ms_Group256_Reserved96</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvtDist</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlope</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlopeDist</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetection</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetectionDist</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSLFnChngSwA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB1SwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB2SwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB3SwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwStuckL</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehboardSetting</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="bb3a20b7abbf3907abd88513465b59f6">
              <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DMSSts_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrAbnormBehvor_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrAbnormConf_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnConf_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnStsINST_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstcnSts_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgConf_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgLvlINST_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgLvl_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrGazeRgn_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrPrst_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeGazepitch_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeGazeyaw_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOnRoad_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOpenDegree_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOpenStatus_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILBRReq_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved143</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved151</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved159</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMM_50ms_Group02_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LeftEyeOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MouthOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OMSSts_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RightEyeOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpfngDet_IMM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/YawnStatus_IMM</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="26b4d95f461436a3a8e6cf5cc415647a">
              <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqToqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts_SCS</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCarGoNotfr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group43_Reserved5</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="ef1b526c3cdc399d905788be7bc14c55">
              <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatAzmth</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosX</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosY</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngLLaneSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngRLaneSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSDirInd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSDrvrTkovReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSSysSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group60_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSysFltSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSysSts_ZPD</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Parkngslottype</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotTkovMsgReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PrkgDstCtrlSwResp</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="12ca337e87353da49bc8d8097530ada5">
              <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqVal</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFnMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSDrvrReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngPrflReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngTrgtDist</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngVelMax</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSReqSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group64_Reserved9</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="adb1da04206a339090b6972c955e0544">
              <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpdV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved103</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved111</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved119</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved127</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved15</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved23</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved31</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved39</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved47</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved55</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved71</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_20ms_Group67_Reserved95</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="e5d7dab2a99336829ea9af0b1e81c37e">
              <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved10</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved11</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved8</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group14_Reserved9</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSInfoDispReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSInfoDispReqToICM</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSProgressBar</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSFObsRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSRObsRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSFObsRng</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSRObsRng</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="0d134740cbd939e1a204cc0e00305d96">
              <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnRunReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_50ms_Group49_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/KeepPwrRsnIPD</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSAFnInd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdCtrl</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="10b3300484683fa2a7be15184add2881">
              <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgCheckSum</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgOVS</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSGW</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSequenceCounter</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTime</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTimeDomain</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgType</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgreserved</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="80021778c0d63c5ab81d41d27048d509">
              <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnIndLampSwStsMntry</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatHorzPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSeatVertPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved103</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved111</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved119</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved12</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved127</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved23</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved31</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved55</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved63</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved71</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved79</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved87</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_100ms_Group30_Reserved95</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="7941fc7b705b3528be4cb73a66fefa7c">
              <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DigKeyAuthReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DigKeyPEValidReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqParkBtn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/KeyAuthResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUAPAUnderCtrlActv</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvMd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvrIntrvnActv</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShiftrFlr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUFltLvlWarn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqEPMCU</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqVEPMCU</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosnLtchActv</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrRawPosn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrOpngRmndr</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrPosnInvsn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecuKeyVldSts</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="295c979aaba1322c865257100669fa59">
              <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnLghtOnReq_LHZCU</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqGearShftPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqGearShftPosInvs</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EleccTrRngReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDayTimeRunningLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCUWKSTS</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_10ms_Group32_Reserved7</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MainBeamLghtSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDayTimeRunningLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLightOnReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUActrMvmntSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvnIntrvnPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShifterActrPos</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkActrSts</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosIncnstntFlag</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosTrgt</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwSta</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwStaInvsn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SideLghtOnReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey4LoctnResp</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnFlrRsn</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnProc</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="68276490e1a636d3bda28a90ae337228">
              <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DippedBeamActStatus</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HzrdLghtSwReq</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved5</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_20ms_Group03_Reserved6</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LMainBeamLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PriySSBA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PriySSBAV</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMainBeamLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtCtrl</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SSBTrigd</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBA</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBAV</SYSTEM-SIGNAL-REF>
              </SYSTEM-SIGNAL-REFS>
            </SYSTEM-SIGNAL-GROUP>
            <SYSTEM-SIGNAL-GROUP UUID="2234909d115c3b6c9e2e059f50b0d26d">
              <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
              <SYSTEM-SIGNAL-REFS>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_CRC</SYSTEM-SIGNAL-REF>
                <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCU_400ms_Group18_RC</SYSTEM-SIGNAL-REF>
