              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU27</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_ICBVC_50ms_PDU14</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_1000ms_PDU67</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU10</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU49</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU01</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU02</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU22</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU23</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU24</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU41</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU64</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU90</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU06</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU07</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU25</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU37</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_100ms_PDU03</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU01</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU02</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU03</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_020ms_PDU18</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU02</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU05</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU20</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TC_IMCU_50ms_PDU28</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TDM_200ms_PDU01</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TPMS_400ms_PDU06</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/Teter_ECM_10ms_PDU20</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU76</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU77</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_BKPCANFD_Rx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_BKPCANFD_Tx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_CHCANFD_Rx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_CHCANFD_Tx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_PTCANFD_Rx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_PTCANFD_Tx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_SFCANFD_Rx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_SFCANFD_Tx</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_FuncReq</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_PhyReq_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_PhyResp_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-CONFIG">/Communication/NetworkManagement/BKPCANFDNmConfig</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-CONFIG">/Communication/NetworkManagement/CHCANFDNmConfig</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-CONFIG">/Communication/NetworkManagement/PTCANFDNmConfig</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-CONFIG">/Communication/NetworkManagement/SFCANFDNmConfig</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="SECURE-COMMUNICATION-PROPS-SET">/Communication/Security/Security_Configuration_Package</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="SECURED-I-PDU">/Communication/PDUs/SecuredIPdu_ICC_SecOC_SyncMsg</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
            <FIBEX-ELEMENT-REF-CONDITIONAL>
              <FIBEX-ELEMENT-REF DEST="SECURED-I-PDU">/Communication/PDUs/SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD</FIBEX-ELEMENT-REF>
            </FIBEX-ELEMENT-REF-CONDITIONAL>
          </FIBEX-ELEMENTS>
          <MAPPINGS>
            <SYSTEM-MAPPING UUID="Oa505a3f19f25843c4b4c6109XOa505a3f19f25843c4b4c610800">
              <SHORT-NAME>Mappings7</SHORT-NAME>
              <DATA-MAPPINGS>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group02/CCU_100ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/CCU_100ms_Group02_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/HVDCDCSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/HVDCDCTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/HVDCHVILSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCHVILSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/HVDCHVILStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCHVILStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/OnBdChrgrHVILStsVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrHVILStsVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/OnBdChrgrHVILStsValV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrHVILStsValV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/PDUHVILSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDUHVILSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02/PDUHVILStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDUHVILStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group07</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group07/CCU_100ms_Group07</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group07</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCUActiveWkup</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUActiveWkup</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCUOnbdChrgrMaxChrgPwr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrMaxChrgPwr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCUOnbdChrgrPlugOn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCUOnbdChrgrPlugOnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCUOnbdChrgrSpRsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrSpRsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/CCU_100ms_Group07_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group07_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrAltrCrntInptCrnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrAltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrAltrCrntInptVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrAltrCrntInptVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrCtrlPilotPWMDuty</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrCtrlPilotPWMDuty</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrCtrlPilotPWMSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrCtrlPilotPWMSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL1AltrCrntInptCrnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL1AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL1AltrCrntInptVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL1AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL2AltrCrntInptCrnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL2AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL2AltrCrntInptVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL2AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL3AltrCrntInptCrnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL3AltrCrntInptCrnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrL3AltrCrntInptVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrL3AltrCrntInptVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrLastWkup</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrLastWkup</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrOtptVolV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrOtptVolV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnBdChrgrWkup</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrWkup</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnbdChrgrAltrCrntInptHVCrntLmt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrAltrCrntInptHVCrntLmt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnbdChrgrOpngMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOpngMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnbdChrgrOtptCrntV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptCrntV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnbdChrgrOtptCrntVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptCrntVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07/OnbdChrgrOtptVolVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrOtptVolVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCU_100ms_Group11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group11/CCU_100ms_Group11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group11</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/AirCtrlrHVILClsd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/AirCtrlrHVILClsdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCUClntFlowReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUClntFlowReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCUOnbdChrgrSktEleccLckEnable</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrSktEleccLckEnable</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/CCU_100ms_Group11_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCU_100ms_Group11_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/ESSPTCHVILSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSPTCHVILSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/ESSPTCHVILStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSPTCHVILStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/HVDCDCClntPumpPWMReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCClntPumpPWMReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/HVDCDCHdwrFlr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCHdwrFlr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11/HVDCDCIntnlFlr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HVDCDCIntnlFlr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_010ms_Group00</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_010ms_Group00/ECM_010ms_Group00</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_010ms_Group00</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/ClOpenReqA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClOpenReqA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/ECM_010ms_Group00_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/ECM_010ms_Group00_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/ECM_010ms_Group00_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/ECM_010ms_Group00_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_010ms_Group00_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnActuStdyStaToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnActuStdyStaToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnActuStdyStaToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnActuStdyStaToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnCCMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnCCMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnCtrlrRunCrkTrmlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnCtrlrRunCrkTrmlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnRunA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnRunA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnSpReqToTr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpReqToTr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnSpdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnSpdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/EnTestMdEnbReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnTestMdEnbReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/IntlckRelayAuth</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IntlckRelayAuth</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/RVSPtCrkAbotd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtCrkAbotd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00/RVSPtRunAbotd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSPtRunAbotd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_25ms_Group36</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_25ms_Group36/ECM_25ms_Group36</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_25ms_Group36</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/AutocTrGearShftDircn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/AutocTrGearShftDircnF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircnF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/DrvlnToqStabSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvlnToqStabSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/ECM_25ms_Group36_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_25ms_Group36_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrCrkshftToqLd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrCrkshftToqLdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrCustSetngDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCustSetngDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrEnASSOvrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEnASSOvrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrInptClStsV_ICE</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClStsV_ICE</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrInptClSts_ICE</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClSts_ICE</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrMinVolReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrMinVolReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrRngInhSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrRngInhSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36/TrWrnngDsp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrWrnngDsp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_500ms_group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_500ms_group02/ECM_500ms_group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_500ms_group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/BarPrsAbs</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbs</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/BarPrsAbsOBD</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsOBD</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/BarPrsAbsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/ECM_500ms_group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/ECM_500ms_group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/ECM_500ms_group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_500ms_group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/EnClntTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnClntTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/EnClntTemV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnClntTemV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/EnIntkAirTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIntkAirTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/EnIntkAirTemV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnIntkAirTemV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/EnWarmUpCycAch</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnWarmUpCycAch</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/OtsdAirTemPtEstd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/OtsdAirTemPtEstdMsk</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstdMsk</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/OtsdAirTemPtEstdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemPtEstdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_500ms_group02/TrClThrmlProtnNotfn_ECM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrClThrmlProtnNotfn_ECM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_ZONE_020ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_ZONE_020ms_Group03/ECM_ZONE_020ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_ZONE_020ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/ECM_020ms_PDU03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_020ms_PDU03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/ECM_020ms_PDU03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_020ms_PDU03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/ECM_ZONE_020ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_020ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/ECM_ZONE_020ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_020ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnASSFrngDet</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSFrngDet</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnASSFuelReqdOn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSFuelReqdOn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnASSSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnASSStallDet</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnASSStallDet</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnAutoSpNotProb</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnAutoSpNotProb</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnToqActuExtdRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqActuExtdRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnToqActuExtdRngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqActuExtdRngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnToqDrvrReqdExtdRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqDrvrReqdExtdRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnToqDrvrReqdExtdRngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqDrvrReqdExtdRngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/EnToqRducnFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqRducnFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03/PropSysA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PropSysA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ECM_ZONE_050ms_Group09</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_ZONE_050ms_Group09</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECM_ZONE_050ms_Group09_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/ECODrvngSpdRutA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ECODrvngSpdRutA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EcoDrvngAIO</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngAIO</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EcoDrvngDspStsGearShftIndSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngDspStsGearShftIndSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EcoDrvngDspStsRcmndFwdGear</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EcoDrvngDspStsRcmndFwdGear</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EnToqMaxExtdRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMaxExtdRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EnToqMaxExtdRngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMaxExtdRngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EnToqMinExtdRng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMinExtdRng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09/EnToqMinExtdRngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnToqMinExtdRngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_010ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_010ms_Group03/EPS_010ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_010ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSAESReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSAESReqTorResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqTorResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSAESReqTorRespV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESReqTorRespV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSAESStsInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAESStsInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSVMCAngRespSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCAngRespSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSVMCCodrivingSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCCodrivingSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPSVMCRespStsInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSVMCRespStsInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPS_010ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPS_010ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPS_010ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPS_010ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03/EPS_010ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_010ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group01/EPS_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ADASStrgDlvrdToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ADASStrgDlvrdToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ActuPnonAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ActuPnonAngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ActuRoadWhlAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ActuRoadWhlAngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/CHLKAHptResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CHLKAHptResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ChLKAAngReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChLKAAngReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/ChLKAToqReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChLKAToqReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/DrvrStrgDlvrdToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrStrgDlvrdToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/DrvrStrgDlvrdToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrStrgDlvrdToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSActRetMotToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSActRetMotToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSActRetMotToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSActRetMotToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSCoDrivingSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSCoDrivingSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSCurntDrvMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSCurntDrvMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSDrvngMdCtrlInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSDrvngMdCtrlInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSLimMotToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSLimMotToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSLimMotToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSLimMotToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSPriyChnlFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSPriyChnlFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSToqValAldMax</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMax</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSToqValAldMaxV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMaxV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSToqValAldMin</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMin</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPSToqValAldMinV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqValAldMinV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/EPS_10ms_Group01_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group01_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01/StrgCustSetngDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgCustSetngDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group02/EPS_10ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/ActuRoadWhlAngGrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/ActuRoadWhlAngGrdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPkgAngReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPkgAngReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPkgAngReqRespInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPkgAngReqRespInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPltAngRespSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAngRespSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPltAngRespStsInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAngRespStsInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPltAvlLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltAvlLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPSAIPltCtrlChannel</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAIPltCtrlChannel</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPS_10ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPS_10ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPS_10ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02/EPS_10ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_10ms_Group05</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group05/EPS_10ms_Group05</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group05</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/EPS_10ms_Group05_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/EPS_10ms_Group05_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/EPS_10ms_Group05_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/EPS_10ms_Group05_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/EPS_10ms_Group05_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_10ms_Group05_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngGrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngGrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngSnsrCalSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrCalSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngSnsrFlt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrFlt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngSnsrInid</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrInid</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngSnsrMultCapb</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrMultCapb</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05/StrgWhlAngV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPS_20ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_20ms_Group03/EPS_20ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_20ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPSAPAInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAPAInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPSAPASts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAPASts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03/EPS_20ms_Group03_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPS_20ms_Group03_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESS_100ms_Group58</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESS_100ms_Group58/ESS_100ms_Group58</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ESS_100ms_Group58</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/BMSOfbdChrgrSktVol</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVol</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/BMSOfbdChrgrSktVolV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVolV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/BMSOffBdChrgrPlugOn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/BMSOffBdChrgrPlugOnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58/ESS_100ms_Group58_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESS_100ms_Group58_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FDR_100ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FDR_100ms_Group01/FDR_100ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FDR_100ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDRSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDRSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01/FDR_100ms_Group01_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDR_100ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FVCM_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FVCM_10ms_Group01/FVCM_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FVCM_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/FVCM_10ms_Group01_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/LKAReqAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/LKAReqAngSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqAngSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/LKAReqToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01/LKAReqToqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKAReqToqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FVCM_20ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FVCM_20ms_Group02/FVCM_20ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FVCM_20ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCDetObjDistLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjDistLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCDrvrSelTrgtSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDrvrSelTrgtSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCGoNotfr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoNotfr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCMsgReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCMsgReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCSeldTrgtDistLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSeldTrgtDistLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCTJAMdSwDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTJAMdSwDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCTotWhlToqReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ACCTotWhlToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ELKSysSts_IPD</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKSysSts_IPD</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/EyeOffRoadDetnSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOffRoadDetnSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/EyeOffRoadDetnStaV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EyeOffRoadDetnStaV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/FVCM_20ms_Group02_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FVCM_20ms_Group02_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/HandOffStrgWhlDetnSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HandOffStrgWhlDetnSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/HandOffStrgWhlDetnStaV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HandOffStrgWhlDetnStaV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ILCActvnDircnDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCActvnDircnDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ILCActvnVelDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCActvnVelDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ILCSwDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCSwDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/ILCSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LDWAdoWrnngDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWAdoWrnngDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LDWLKAAudReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAAudReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LDWLKADspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKADspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LDWLKAHptWrnngDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAHptWrnngDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LDWSnstvtLvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSnstvtLvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02/LKADrvrTkovReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LKADrvrTkovReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group08</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group08/IAM_100ms_Group08</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group08</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/AltSigma</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltSigma</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/IAM_100ms_Group08_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/IAM_100ms_Group08_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/IAM_100ms_Group08_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group08_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/LatSigma</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LatSigma</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group08/LonSigma</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LonSigma</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group18/IAM_100ms_Group18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group18</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/HeadingSigma</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HeadingSigma</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/IAM_100ms_Group18_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/IAM_100ms_Group18_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/IAM_100ms_Group18_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group18_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/PitchRTK</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PitchRTK</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group18/PitchSigma</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PitchSigma</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_100ms_Group56</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group56/IAM_100ms_Group56</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group56</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/IAM_100ms_Group56_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/IAM_100ms_Group56_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/IAM_100ms_Group56_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/IAM_100ms_Group56_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_100ms_Group56_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/IAM_GNSS_Signal_Status</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_GNSS_Signal_Status</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_100ms_Group56/LatitudeRTK</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LatitudeRTK</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_20ms_Group32</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_20ms_Group32/IAM_20ms_Group32</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_20ms_Group32</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/IAM_20ms_Group32_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_20ms_Group32_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtDrvrTrgtEPSStrgWhlAng</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtDrvrTrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtParkngAstAbotBtnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstAbotBtnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtParkngAstBtnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstBtnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtParkngAstDvcFlrRsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcFlrRsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtParkngAstDvcSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/RmtParkngAstParkngOutDircnSeln</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstParkngOutDircnSeln</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehBkwdSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehBkwdSwReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehBkwdSwReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehFwdSwReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehFwdSwReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehFwdSwReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehRoadWhlLReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehRoadWhlLReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlLReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehRoadWhlRReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_20ms_Group32/VehRoadWhlRReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehRoadWhlRReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group13/IAM_ZONE_100ms_Group13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group13</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/FixType</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FixType</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/GNSSSeq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSSeq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/GNSSUTCTimeH</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSUTCTimeH</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/IAM_ZONE_100ms_Group13_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/IAM_ZONE_100ms_Group13_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group13/IAM_ZONE_100ms_Group13_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group13_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group34</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group34</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/Hdop</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Hdop</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group34_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/Pdop</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Pdop</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group34/Vdop</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Vdop</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group35</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group35/IAM_ZONE_100ms_Group35</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group35</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35/GNSSF9HCounter</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSF9HCounter</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35/GNSSUTCTime</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSUTCTime</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35/IAM_ZONE_100ms_Group35_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35/IAM_ZONE_100ms_Group35_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group35/IAM_ZONE_100ms_Group35_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group35_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group40</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group40</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/AltitudeRTK</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltitudeRTK</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/HeadingRTK</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HeadingRTK</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group40_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAM_ZONE_100ms_Group57</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group57</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAM_ZONE_100ms_Group57_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IAM_ZONE_100ms_Group57/LongitudeRTK</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LongitudeRTK</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_100ms_Group15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_100ms_Group15/IBS_100ms_Group15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_100ms_Group15</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/BrkFltAlrm_GB</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFltAlrm_GB</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/BrkFrc_GB</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFrc_GB</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/CsbLvlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CsbLvlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/DistRCAvgDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/DistRCAvgDrvnRstOcd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnRstOcd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/DistRCAvgDrvnSrc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnSrc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/DistRCAvgDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistRCAvgDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBSABSlvlResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSABSlvlResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBSESPlvlResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSESPlvlResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBSTCSlvlResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSTCSlvlResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_100ms_Group15/IBS_100ms_Group15_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_100ms_Group15_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group01/IBS_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlDistPlsCtr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistPlsCtr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlDistTRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlDistTmsp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistTmsp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlDistV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlRstOcd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/LDrvnWhlRotlSeqNum</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlDistPlsCtr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistPlsCtr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlDistTRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlDistTmsp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistTmsp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlDistV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlRstOcd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group01/RDrvnWhlRotlSeqNum</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group02/IBS_10ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlDistPC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistPC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlDistT</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistT</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlDistTRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlDistV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlRstOcd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/LNonDrvnWhlRotlSeqNum</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlDistPC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistPC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlDistT</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistT</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlDistTRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistTRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlDistV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDistV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlRstOcd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlRstOcd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group02/RNonDrvnWhlRotlSeqNum</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlSeqNum</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_10ms_Group04</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group04/IBS_10ms_Group04</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group04</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/BrkPdlPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/BrkPdlPosV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPosV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/BrkSysBrkLghtsReqd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysBrkLghtsReqd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/ChSysEnToqReqProtn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysEnToqReqProtn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/EPBSysBrkLghtsReqdA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysBrkLghtsReqdA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_10ms_Group04/IBS_10ms_Group04_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_10ms_Group04_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group07</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group07/IBS_20ms_Group07</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group07</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/ABSA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/ABSF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/ABSIO</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSIO</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/AVHSigPdlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVHSigPdlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/AutoHoldMdSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMdSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/AutoHoldMsg</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMsg</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/AutoHoldSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/BrkSysHillStAstAvlbl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstAvlbl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/BrkSysHillStAstSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/BrkSysRedBrkTlltReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRedBrkTlltReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/BrkSysYlwBrkTlltReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysYlwBrkTlltReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/EBDA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EBDA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/EBDFaultSt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EBDFaultSt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/EmgcBrkA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/EmgcBrkAV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkAV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/EnDragToqRducnA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EnDragToqRducnA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/HBAActiveSt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HBAActiveSt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/HBAValidSt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HBAValidSt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/HDCSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HDCSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/IBS_20ms_Group07_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/IBS_20ms_Group07_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group07_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/MSRA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MSRA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/MSRF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MSRF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/MulColBrkA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MulColBrkA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/MulColBrkAvlblySts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MulColBrkAvlblySts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/MultColBrkEnbA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MultColBrkEnbA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/RgtvBrkFnFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/RgtvBrkFnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/SoftSpSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SoftSpSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/TCSA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/TCSEnbd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSEnbd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/TCSOpngMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/TCSOpngSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/VSEMd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSEMd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/VSESts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group07/VSESysA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSESysA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group08</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group08/IBS_20ms_Group08</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group08</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/ChSysSecyBrkAxleToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysSecyBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/ChSysSecyBrkAxleToqValV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysSecyBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/ChSysTrBrkAxleToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTrBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/ChSysTrBrkAxleToqValV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTrBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBAPAAvlbl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAPAAvlbl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBAppcnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAppcnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBAvlblySts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAvlblySts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBCCCanclReqd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBCCCanclReqd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSwSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSwSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSwStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSwStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSysAudWrnngReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysAudWrnngReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSysDspMsgReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysDspMsgReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSysStsIndReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysStsIndReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/EPBSysWrnngIndReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBSysWrnngIndReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/IBS_20ms_Group08_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group08/IBS_20ms_Group08_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group08_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group09</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group09/IBS_20ms_Group09</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group09</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/ChSysTotBrkAxleToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTotBrkAxleToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/ChSysTotBrkAxleToqValV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChSysTotBrkAxleToqValV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/IBS_20ms_Group09_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/IBS_20ms_Group09_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/IBS_20ms_Group09_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/LDrvnWhlRotlDircn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/LDrvnWhlRotlDircnSdslSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/RDrvnWhlRotlDircn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/RDrvnWhlRotlDircnSdslSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/WhlGndVelLDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/WhlGndVelLDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/WhlGndVelRDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group09/WhlGndVelRDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group10/IBS_20ms_Group10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group10</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkDiscTemSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkDiscTemSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkFludLvlLow</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLow</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkFludLvlLowV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLowV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlAppd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlAppdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlDrvrAppdPrs</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrs</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlDrvrAppdPrsDet</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDet</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlDrvrAppdPrsDetV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDetV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlDrvrAppdPrsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlMdlActSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlActSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlMdlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlSimltdPrs</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrs</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/BrkPdlSimltdPrsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/DrvrReqOtptRodTrvl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqOtptRodTrvl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/DrvrReqOtptRodTrvlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrReqOtptRodTrvlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/IBS_20ms_Group10_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/IBS_20ms_Group10_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/IBS_20ms_Group10_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group10/IBS_20ms_Group10_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group11/IBS_20ms_Group11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group11</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/IBS_20ms_Group11_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/IBS_20ms_Group11_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/IBS_20ms_Group11_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group11_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvg</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvg</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgDrvnSrc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnSrc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgNonDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgNonDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgNonDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group11/VehSpdAvgV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSpdAvgV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group12/IBS_20ms_Group12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group12</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/IBS_20ms_Group12_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/IBS_20ms_Group12_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/IBS_20ms_Group12_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/IBS_20ms_Group12_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group12_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/LNonDrvnWhlRotlDircn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/LNonDrvnWhlRotlDircnSdslSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LNonDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/RNonDrvnWhlRotlDircn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/RNonDrvnWhlRotlDircnSdslSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RNonDrvnWhlRotlDircnSdslSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/WhlGndVelLNonDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/WhlGndVelLNonDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelLNonDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/WhlGndVelRNonDrvn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group12/WhlGndVelRNonDrvnV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlGndVelRNonDrvnV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_20ms_Group13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group13/IBS_20ms_Group13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group13</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ACCBrkngA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCBrkngA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/AutodDrvngSysMdReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/AutodDrvngSysMdReqRespV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqRespV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/BrkSysRddySysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRddySysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChACCAccReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChACCAccReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChACCReqFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChACCReqFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChAEBBrkJerkReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBBrkJerkReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChAEBDclReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBDclReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChAEBHydBrkAstReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBHydBrkAstReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChAEBPrflReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChAEBPrflReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChEBADclReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChEBADclReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChRCTBDclReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChRCTBDclReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ChRCTBPrflReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChRCTBPrflReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/EmgcBrkReqdByIECUSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EmgcBrkReqdByIECUSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ExtnlBrkPrio</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ExtnlBrkPrio</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/ExtnlBrkPrioV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ExtnlBrkPrioV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/IBSAPASysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSAPASysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/IBS_20ms_Group13_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group13_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/IBS_20ms_Group13_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_20ms_Group13_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/MultColBrkAvlblySts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MultColBrkAvlblySts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSAPAAcclA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSAPAAcclAV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclAV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSAutodDrvngSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSAutodDrvngSysStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSVehHoldA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/SCSVehHoldAV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldAV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/TCSDrvrItnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSDrvrItnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/VehSdslSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/VehSdslStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSdslStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_20ms_Group13/WhlBrkPrsSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlBrkPrsSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_ZONE_20ms_Group08</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_ZONE_20ms_Group08</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/BrkBstFnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkBstFnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/EPBAppcnSts_M</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPBAppcnSts_M</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBSRespAccToqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBSRespAccToqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/IBS_ZONE_20ms_Group08/IBS_ZONE_20ms_Group08_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_ZONE_20ms_Group08_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_100ms_Group25</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group25/ICBAD_100ms_Group25</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_100ms_Group25</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved135</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved135</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved143</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved143</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved151</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved151</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved159</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved159</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved167</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved167</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved175</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved175</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved183</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved183</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved191</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved191</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved87</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved87</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/ICBAD_100ms_Group25_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group25_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/MemPkngSlntPtrlEnbSwResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSlntPtrlEnbSwResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/MemPkngSwResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSwResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group25/PEBSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_100ms_Group37</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group37/ICBAD_100ms_Group37</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_100ms_Group37</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/AutoLaneChngMsgReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngMsgReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/AutoLaneChngSetResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSetResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/AutoLaneChngSwDspCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSwDspCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/DILampsCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DILampsCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/HzrdLampsCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HzrdLampsCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_100ms_Group37/ICBAD_100ms_Group37_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_100ms_Group37_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_10ms_Group01/ICBAD_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/EPSToqAppdCoefnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSToqAppdCoefnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved16</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved16</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved17</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved17</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved18</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved18</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved19</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved19</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved20</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved20</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved21</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved21</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved22</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved22</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/ICBAD_10ms_Group01_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_10ms_Group01_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/PltEPSRdWhlAngReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PltEPSRdWhlAngReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_10ms_Group01/PltEPSRdWhlAngReqStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PltEPSRdWhlAngReqStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group05</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group05/ICBAD_20ms_Group05</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group05</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/APACrpSpdReqVal_IPD</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACrpSpdReqVal_IPD</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/APARevrDrgReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APARevrDrgReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/APAToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/APATotWhlToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATotWhlToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/APAVCUReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVCUReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group05/ICBAD_20ms_Group05_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group05_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group07</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group07/ICBAD_20ms_Group07</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group07</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCAccReqSts_CH</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqSts_CH</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCAccReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCGoReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCSdslReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSdslReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCSysFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ACCSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AIPkgAPASCSAcclReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPkgAPASCSAcclReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/APAEPBOPReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/APAEPBOPReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/APASCSAcclReqSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSAcclReqSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysEmgcBrkReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysEmgcBrkReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysFlrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysFlrStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysMdReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysMdReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysSCSDrvOffReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysSCSDrvOffReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysSCSSdslReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/AutodDrvngSysSCSSdslReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ICBAD_20ms_Group07_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ICBAD_20ms_Group07_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group07/ICBAD_20ms_Group07_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group07_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group09</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group09/ICBAD_20ms_Group09</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group09</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/ICBAD_20ms_Group09_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group09_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/NSABacSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSABacSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/NSADisFucSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSADisFucSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/NSAForSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSAForSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group09/NSAReqAVMDis</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NSAReqAVMDis</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICBAD_20ms_Group12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group12/ICBAD_20ms_Group12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group12</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/APASts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/AutodDrvngSysSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/AutodDrvngSysStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/ICBAD_20ms_Group12/ICBAD_20ms_Group12_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICBAD_20ms_Group12_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
