                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHORWarningEvtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbce200">
                          <SHORT-NAME>HPPFnSts_HPPFnSts_HPPFnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HPPFnSts_HPPFnSts_HPPFnSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPFnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc8800">
                          <SHORT-NAME>HPPInBmtSts_HPPInBmtSts_HPPInBmtSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HPPInBmtSts_HPPInBmtSts_HPPInBmtSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPInBmtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf1d00">
                          <SHORT-NAME>HPPMapBuildSts_HPPMapBuildSts_HPPMapBuildSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HPPMapBuildSts_HPPMapBuildSts_HPPMapBuildSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPMapBuildSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbfef00">
                          <SHORT-NAME>HPPOnRoutSts_HPPOnRoutSts_HPPOnRoutSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HPPOnRoutSts_HPPOnRoutSts_HPPOnRoutSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHPPOnRoutSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf98d00">
                          <SHORT-NAME>HUDLkngAmbtLghtLvlByLux_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HUDLkngAmbtLghtLvlByLux_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDLkngAmbtLghtLvlByLux</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfacf00">
                          <SHORT-NAME>HandOffStrgWhlDetnSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HandOffStrgWhlDetnSta_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfae000">
                          <SHORT-NAME>HandOffStrgWhlDetnStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HandOffStrgWhlDetnStaV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb7be00">
                          <SHORT-NAME>Hdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Hdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHdop</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbc26d00">
                          <SHORT-NAME>HeadingRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HeadingRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHeadingRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbd1c00">
                          <SHORT-NAME>HeadingSigma_IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HeadingSigma_IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHeadingSigma</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03de00">
                          <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HmdtySnsrHdwrFltPrst_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHmdtySnsrHdwrFltPrst</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdcb500">
                          <SHORT-NAME>HzrdLampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HzrdLampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHzrdLampsCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba69c00">
                          <SHORT-NAME>HzrdLghtSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HzrdLghtSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHzrdLghtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd5c900">
                          <SHORT-NAME>IACCOvTSuppresCmd_IACCOvTSuppresCmd_IACCOvTSuppresCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IACCOvTSuppresCmd_IACCOvTSuppresCmd_IACCOvTSuppresCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCOvTSuppresCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd69c00">
                          <SHORT-NAME>IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IACCOvTSuppresSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCOvTSuppresSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd61500">
                          <SHORT-NAME>IACCPreMsgReq_IACCPreMsgReq_IACCPreMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IACCPreMsgReq_IACCPreMsgReq_IACCPreMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd58c00">
                          <SHORT-NAME>IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IACCPreSpdLimtCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreSpdLimtCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd6c900">
                          <SHORT-NAME>IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreSpdLimtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc40200">
                          <SHORT-NAME>IAMAvlbly</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAMAvlbly_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAMAvlbly</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba9b700">
                          <SHORT-NAME>IAMReststs_IAMReststs_IAMReststs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAMReststs_IAMReststs_IAMReststs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAMReststs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0638bf00">
                          <SHORT-NAME>IAM_100ms_Group08_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group08_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbf0a00">
                          <SHORT-NAME>IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_100ms_Group08</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e063a0900">
                          <SHORT-NAME>IAM_100ms_Group08_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group08_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e063b5500">
                          <SHORT-NAME>IAM_100ms_Group08_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group08_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e063ea600">
                          <SHORT-NAME>IAM_100ms_Group18_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group18_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbce600">
                          <SHORT-NAME>IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_100ms_Group18</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e063ff400">
                          <SHORT-NAME>IAM_100ms_Group18_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group18_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06413900">
                          <SHORT-NAME>IAM_100ms_Group18_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group18_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06683400">
                          <SHORT-NAME>IAM_100ms_Group56_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group56_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbafd00">
                          <SHORT-NAME>IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_100ms_Group56</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e066ad000">
                          <SHORT-NAME>IAM_100ms_Group56_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group56_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e066c1900">
                          <SHORT-NAME>IAM_100ms_Group56_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group56_Reserved13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06698400">
                          <SHORT-NAME>IAM_100ms_Group56_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_100ms_Group56_Reserved63_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce2900">
                          <SHORT-NAME>IAM_20ms_Group32_CRC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_CRC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcd4800">
                          <SHORT-NAME>IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_20ms_Group32</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce3800">
                          <SHORT-NAME>IAM_20ms_Group32_RC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_RC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcedd00">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf4000">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcee800">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcef300">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcefe00">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf0900">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf1400">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf1f00">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf2a00">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved8_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf3500">
                          <SHORT-NAME>IAM_20ms_Group32_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_20ms_Group32_Reserved9_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbb3300">
                          <SHORT-NAME>IAM_GNSS_Signal_Status_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_GNSS_Signal_Status_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_GNSS_Signal_Status</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06444600">
                          <SHORT-NAME>IAM_ZONE_100ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group13_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb56400">
                          <SHORT-NAME>IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_ZONE_100ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06459700">
                          <SHORT-NAME>IAM_ZONE_100ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group13_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0646e200">
                          <SHORT-NAME>IAM_ZONE_100ms_Group13_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group13_Reserved13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0649e900">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb78800">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_ZONE_100ms_Group34</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e064f2100">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06506600">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e064b3900">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_Reserved23_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e064c8400">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_Reserved39_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e064dd100">
                          <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group34_Reserved55_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e065ad400">
                          <SHORT-NAME>IAM_ZONE_100ms_Group35_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group35_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb96000">
                          <SHORT-NAME>IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_ZONE_100ms_Group35</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e065c1e00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group35_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group35_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e065d6a00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group35_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group35_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0660a100">
                          <SHORT-NAME>IAM_ZONE_100ms_Group40_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group40_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbc20200">
                          <SHORT-NAME>IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_ZONE_100ms_Group40</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06633700">
                          <SHORT-NAME>IAM_ZONE_100ms_Group40_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group40_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06648200">
                          <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group40_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0661ea00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group40_Reserved63_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e066fba00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group57_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group57_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbc0a000">
                          <SHORT-NAME>IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIAM_ZONE_100ms_Group57</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06725600">
                          <SHORT-NAME>IAM_ZONE_100ms_Group57_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group57_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06739b00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group57_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06710a00">
                          <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_Group57_Reserved63_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcfe200">
                          <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IBS_CHAvlbly_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_CHAvlbly</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c011600">
                          <SHORT-NAME>ICBAD_100ms_Group25_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bffc400">
                          <SHORT-NAME>ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_100ms_Group25</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c021300">
                          <SHORT-NAME>ICBAD_100ms_Group25_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c018f00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved103_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c019a00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved111_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01a500">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved119_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01b000">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved127_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01bb00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved135</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved135_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved135</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01c600">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved143</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved143_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved143</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c021e00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved15_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01d100">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved151</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved151_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved151</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01dc00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved159</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved159_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved159</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01e700">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved167</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved167_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved167</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01f200">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved175</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved175_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved175</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c01fd00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved183</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved183_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved183</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c020800">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved191</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved191_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved191</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c012100">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved23_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c012c00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved31_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c013700">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved39_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c014200">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved47_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c014d00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved55_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c015800">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved63_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c016300">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved71_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c016e00">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved79_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c017900">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved87</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved87_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved87</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c018400">
                          <SHORT-NAME>ICBAD_100ms_Group25_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group25_Reserved95_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be27c00">
                          <SHORT-NAME>ICBAD_100ms_Group37_CRC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_CRC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc6a00">
                          <SHORT-NAME>ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_100ms_Group37</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be28b00">
                          <SHORT-NAME>ICBAD_100ms_Group37_RC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_RC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6ae00">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6b900">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6c400">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6cf00">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6da00">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6e500">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6f000">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be6fb00">
                          <SHORT-NAME>ICBAD_100ms_Group37_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_Group37_Reserved8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f40700">
                          <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group05</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f50f00">
                          <SHORT-NAME>ICBAD_20ms_Group05_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f54300">
                          <SHORT-NAME>ICBAD_20ms_Group05_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f5ab00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f77f00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved10_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f7b300">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved11_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f7e700">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved12_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f81b00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved13_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f84f00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f88300">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved15_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f5df00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f61300">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f64700">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f67b00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f6af00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f6e300">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f71700">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f74b00">
                          <SHORT-NAME>ICBAD_20ms_Group05_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group05_Reserved9_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bec7600">
                          <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group07</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group07_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beca300">
                          <SHORT-NAME>ICBAD_20ms_Group07_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group07_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becb200">
                          <SHORT-NAME>ICBAD_20ms_Group07_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group07_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be70600">
                          <SHORT-NAME>ICBAD_20ms_Group07_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group07_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be25e00">
                          <SHORT-NAME>ICBAD_20ms_Group09_CRC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_CRC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc1000">
                          <SHORT-NAME>ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group09</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be26d00">
                          <SHORT-NAME>ICBAD_20ms_Group09_RC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_RC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be63000">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be63b00">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be64600">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be65100">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be65c00">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be66700">
                          <SHORT-NAME>ICBAD_20ms_Group09_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group09_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcced00">
                          <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group12</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcd1a00">
                          <SHORT-NAME>ICBAD_20ms_Group12_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcd2900">
                          <SHORT-NAME>ICBAD_20ms_Group12_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c02ce00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c02d900">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c02e400">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c02ef00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c02fa00">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c030500">
                          <SHORT-NAME>ICBAD_20ms_Group12_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group12_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124b2500">
                          <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124b0b00">
                          <SHORT-NAME>ICBAD_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124b1800">
                          <SHORT-NAME>ICBAD_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124a6f00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124a7c00">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124a8900">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124a9600">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124aa300">
                          <SHORT-NAME>ICBAD_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group13_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bee7400">
                          <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group46</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group46_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beefb00">
                          <SHORT-NAME>ICBAD_20ms_Group46_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group46_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef0a00">
                          <SHORT-NAME>ICBAD_20ms_Group46_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group46_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be7cc00">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group46_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be7d700">
                          <SHORT-NAME>ICBAD_20ms_Group46_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group46_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7b300">
                          <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_20ms_Group48</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc86700">
                          <SHORT-NAME>ICBAD_20ms_Group48_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc87600">
                          <SHORT-NAME>ICBAD_20ms_Group48_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7c200">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7d100">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7e000">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7ef00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7fe00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc80d00">
                          <SHORT-NAME>ICBAD_20ms_Group48_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_Group48_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc74a00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBAD_ZONE_20ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc79500">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc7a400">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1d100">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1dc00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1e700">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1f200">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1fd00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd20800">
                          <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e068f5a00">
                          <SHORT-NAME>ICBVC_100ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd5e300">
                          <SHORT-NAME>ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_100ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06bc0100">
                          <SHORT-NAME>ICBVC_100ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06b0dd00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved103_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06b3a700">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved111_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06b66700">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved119_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06b94000">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved127_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06becc00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved14_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06923200">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved21</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved21_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved21</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0694fc00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved31_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0697c700">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved47_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e069a9100">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved55_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e069d5c00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved63_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06a02600">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved71_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06a5bd00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved72</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved72_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved72</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06a2ee00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved79_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06ab4e00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved80</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved80_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved80</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06a87d00">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved84</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved84_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved84</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06ae1200">
                          <SHORT-NAME>ICBVC_100ms_Group01_Reserved92</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group01_Reserved92_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved92</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef1900">
                          <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_100ms_Group80</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3befaf00">
                          <SHORT-NAME>ICBVC_100ms_Group80_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3befbe00">
                          <SHORT-NAME>ICBVC_100ms_Group80_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef4600">
                          <SHORT-NAME>ICBVC_100ms_Group80_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef5500">
                          <SHORT-NAME>ICBVC_100ms_Group80_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef6400">
                          <SHORT-NAME>ICBVC_100ms_Group80_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_Group80_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3befcd00">
                          <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_200ms_Group79</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_Group79_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf01800">
                          <SHORT-NAME>ICBVC_200ms_Group79_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_Group79_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf02700">
                          <SHORT-NAME>ICBVC_200ms_Group79_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_Group79_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c031000">
                          <SHORT-NAME>ICBVC_200ms_Group79_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_Group79_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c031b00">
                          <SHORT-NAME>ICBVC_200ms_Group79_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_Group79_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf04500">
                          <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_20ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf09000">
                          <SHORT-NAME>ICBVC_20ms_Group03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf09f00">
                          <SHORT-NAME>ICBVC_20ms_Group03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf05400">
                          <SHORT-NAME>ICBVC_20ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf06300">
                          <SHORT-NAME>ICBVC_20ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf07200">
                          <SHORT-NAME>ICBVC_20ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf08100">
                          <SHORT-NAME>ICBVC_20ms_Group03_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_Group03_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d13200">
                          <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group11</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d16700">
                          <SHORT-NAME>ICBVC_50ms_Group11_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d19b00">
                          <SHORT-NAME>ICBVC_50ms_Group11_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d67b00">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d6af00">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d6e300">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d71700">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d74b00">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d78500">
                          <SHORT-NAME>ICBVC_50ms_Group11_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group11_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be59a00">
                          <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group13</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be61200">
                          <SHORT-NAME>ICBVC_50ms_Group13_CRC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_CRC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be62100">
                          <SHORT-NAME>ICBVC_50ms_Group13_RC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_RC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be95900">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9bc00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9c700">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved11_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9d200">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved12_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9dd00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9e800">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved14_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved14</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9f300">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved15_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9fe00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved16</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved16_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved16</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be96400">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be96f00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be97a00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be98500">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be99000">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be99b00">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9a600">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved8_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be9b100">
                          <SHORT-NAME>ICBVC_50ms_Group13_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group13_Reserved9_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc36500">
                          <SHORT-NAME>ICBVC_50ms_Group158_CRC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_CRC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc35500">
                          <SHORT-NAME>ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group158</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc37500">
                          <SHORT-NAME>ICBVC_50ms_Group158_RC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_RC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea0900">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea7500">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea8100">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved11_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea8d00">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved12_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea9900">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved13</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea1500">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea2100">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea2d00">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea3900">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea4500">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea5100">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea5d00">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved8_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bea6900">
                          <SHORT-NAME>ICBVC_50ms_Group158_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_Group158_Reserved9_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be88700">
                          <SHORT-NAME>ICMDrvrDstcnSts_ICMDrvrDstcnSts_ICMDrvrDstcnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMDrvrDstcnSts_ICMDrvrDstcnSts_ICMDrvrDstcnSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrDstcnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be85a00">
                          <SHORT-NAME>ICMDrvrFtgLvl_ICMDrvrFtgLvl_ICMDrvrFtgLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMDrvrFtgLvl_ICMDrvrFtgLvl_ICMDrvrFtgLvl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrFtgLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be87800">
                          <SHORT-NAME>ICMDrvrPrst_ICMDrvrPrst_ICMDrvrPrst</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMDrvrPrst_ICMDrvrPrst_ICMDrvrPrst_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrPrst</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be86900">
                          <SHORT-NAME>ICMEyeOnRoad_ICMEyeOnRoad_ICMEyeOnRoad</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMEyeOnRoad_ICMEyeOnRoad_ICMEyeOnRoad_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMEyeOnRoad</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f3a1b41323305400">
                          <SHORT-NAME>ICMSwReq_Reserve16_ICMSwReq_Reserve16_ICMSwReq_Reserve16</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMSwReq_Reserve16_ICMSwReq_Reserve16_ICMSwReq_Reserve16_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMSwReq_Reserve16</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f3a1b4132330c500">
                          <SHORT-NAME>ICMSwReq_Reserve17_ICMSwReq_Reserve17_ICMSwReq_Reserve17</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICMSwReq_Reserve17_ICMSwReq_Reserve17_ICMSwReq_Reserve17_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMSwReq_Reserve17</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c09f000">
                          <SHORT-NAME>ILBRReq_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILBRReq_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILBRReq_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfaf100">
                          <SHORT-NAME>ILCActvnDircnDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILCActvnDircnDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnDircnDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb0200">
                          <SHORT-NAME>ILCActvnVelDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILCActvnVelDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnVelDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb1300">
                          <SHORT-NAME>ILCSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILCSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a5c00">
                          <SHORT-NAME>ILCSwReq_ILCSwReq_ILCSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILCSwReq_ILCSwReq_ILCSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb2400">
                          <SHORT-NAME>ILCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ILCSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf18f00">
                          <SHORT-NAME>IMATESysSts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMATESysSts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMATESysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c09d000">
                          <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIMM_50ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0aa000">
                          <SHORT-NAME>IMM_50ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ab000">
                          <SHORT-NAME>IMM_50ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0efc00">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f5f00">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e0630aa00">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved143</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved143_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved143</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06328700">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved151</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved151_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved151</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f8c72e8e06345400">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved159</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved159_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved159</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f0700">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f1200">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f1d00">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f2800">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f3300">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f3e00">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f4900">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved8_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f5400">
                          <SHORT-NAME>IMM_50ms_Group02_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_Group02_Reserved9_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcbee00">
                          <SHORT-NAME>IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPDAVCamrHeatReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDAVCamrHeatReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf9300">
                          <SHORT-NAME>IPDAlgFlag_IPDAlgFlag_IPDAlgFlag</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDAlgFlag_IPDAlgFlag_IPDAlgFlag_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDAlgFlag</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae9400">
                          <SHORT-NAME>IPDAurixTemp_IPDAurixTemp_IPDAurixTemp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDAurixTemp_IPDAurixTemp_IPDAurixTemp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDAurixTemp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf6600">
                          <SHORT-NAME>IPDComKeyEnbResp_IPDComKeyEnbResp_IPDComKeyEnbResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDComKeyEnbResp_IPDComKeyEnbResp_IPDComKeyEnbResp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDComKeyEnbResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf4800">
                          <SHORT-NAME>IPDDataId_IPDDataId_IPDDataId</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDDataId_IPDDataId_IPDDataId_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDDataId</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf0c00">
                          <SHORT-NAME>IPDErrorCount_IPDErrorCount_IPDErrorCount</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDErrorCount_IPDErrorCount_IPDErrorCount_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDErrorCount</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf7500">
                          <SHORT-NAME>IPDFailedReason_IPDFailedReason_IPDFailedReason</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDFailedReason_IPDFailedReason_IPDFailedReason_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDFailedReason</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf8400">
                          <SHORT-NAME>IPDIdentityResp_IPDIdentityResp_IPDIdentityResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDIdentityResp_IPDIdentityResp_IPDIdentityResp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDIdentityResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf3900">
                          <SHORT-NAME>IPDKeyStatus_IPDKeyStatus_IPDKeyStatus</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDKeyStatus_IPDKeyStatus_IPDKeyStatus_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDKeyStatus</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2a100">
                          <SHORT-NAME>IPDMCUTemp_IPDMCUTemp_IPDMCUTemp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDMCUTemp_IPDMCUTemp_IPDMCUTemp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDMCUTemp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae8500">
                          <SHORT-NAME>IPDPCBTemp1_IPDPCBTemp1_IPDPCBTemp1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDPCBTemp1_IPDPCBTemp1_IPDPCBTemp1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPCBTemp1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae7600">
                          <SHORT-NAME>IPDPCBTemp2_IPDPCBTemp2_IPDPCBTemp2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDPCBTemp2_IPDPCBTemp2_IPDPCBTemp2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPCBTemp2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baed000">
                          <SHORT-NAME>IPDPMICTemp_IPDPMICTemp_IPDPMICTemp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDPMICTemp_IPDPMICTemp_IPDPMICTemp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPMICTemp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2b000">
                          <SHORT-NAME>IPDPowerFailSwReq_IPDPowerFailSwReq_IPDPowerFailSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDPowerFailSwReq_IPDPowerFailSwReq_IPDPowerFailSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDPowerFailSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf2a00">
                          <SHORT-NAME>IPDResetCnt_IPDResetCnt_IPDResetCnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDResetCnt_IPDResetCnt_IPDResetCnt_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDResetCnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae5800">
                          <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDSOCTemp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDSOCTemp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baec100">
                          <SHORT-NAME>IPDStsResp_IPDStsResp_IPDStsResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDStsResp_IPDStsResp_IPDStsResp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDStsResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baea300">
                          <SHORT-NAME>IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPDThermalWrnngLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDThermalWrnngLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bafa200">
                          <SHORT-NAME>IPDTripCntResetResp_IPDTripCntResetResp_IPDTripCntResetResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDTripCntResetResp_IPDTripCntResetResp_IPDTripCntResetResp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDTripCntResetResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf5700">
                          <SHORT-NAME>IPDTripCnt_IPDTripCnt_IPDTripCnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDTripCnt_IPDTripCnt_IPDTripCnt_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDTripCnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baf1b00">
                          <SHORT-NAME>IPDTripNvmTag_IPDTripNvmTag_IPDTripNvmTag</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDTripNvmTag_IPDTripNvmTag_IPDTripNvmTag_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDTripNvmTag</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baeb200">
                          <SHORT-NAME>IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDWtrClntInltFlwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc29200">
                          <SHORT-NAME>IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDWtrClntInltReqFlg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae6700">
                          <SHORT-NAME>IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPDWtrClntInltTimeReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be29a00">
                          <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdde400">
                          <SHORT-NAME>IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group43</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be2a900">
                          <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be71100">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be71c00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be72700">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be73200">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be73d00">
                          <SHORT-NAME>IPD_20ms_Group43_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group43_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be2b800">
                          <SHORT-NAME>IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdcc400">
                          <SHORT-NAME>IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_20ms_Group60</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be2c800">
                          <SHORT-NAME>IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f6a00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fcd00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved10_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fd800">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved11_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f7500">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f8b00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0f9600">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fa100">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fac00">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fb700">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fc200">
                          <SHORT-NAME>IPD_20ms_Group60_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_Group60_Reserved9_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcebf00">
                          <SHORT-NAME>IPD_50ms_Group14_CRC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_CRC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce4700">
                          <SHORT-NAME>IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group14</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcece00">
                          <SHORT-NAME>IPD_50ms_Group14_RC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_RC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf4b00">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcfae00">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved10_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved10</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcfb900">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved11</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved11_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved11</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf5600">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf6100">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf6c00">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf7700">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf8200">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf8d00">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcf9800">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcfa300">
                          <SHORT-NAME>IPD_50ms_Group14_Reserved9</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group14_Reserved9_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved9</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be19600">
                          <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_50ms_Group49</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be1b400">
                          <SHORT-NAME>IPD_50ms_Group49_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be1c300">
                          <SHORT-NAME>IPD_50ms_Group49_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beaa500">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beab000">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beabb00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beac600">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bead100">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beadc00">
                          <SHORT-NAME>IPD_50ms_Group49_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_Group49_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba3bd00">
                          <SHORT-NAME>IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba41700">
                          <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba42600">
                          <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba2fa00">
                          <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba3db00">
                          <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba31800">
                          <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba35400">
                          <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba3f900">
                          <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba3ea00">
                          <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba40800">
                          <SHORT-NAME>IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba39000">
                          <SHORT-NAME>IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_BKPCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba44400">
                          <SHORT-NAME>IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IIPD_Sporadic_TimeSync_Group</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbe0000">
                          <SHORT-NAME>IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_VehLckCtrlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_VehLckCtrlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baffc00">
                          <SHORT-NAME>IdentityChlg_IdentityChlg_IdentityChlg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IdentityChlg_IdentityChlg_IdentityChlg_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIdentityChlg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbdb500">
                          <SHORT-NAME>JAMsgReq_JAMsgReq_JAMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/JAMsgReq_JAMsgReq_JAMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IJAMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be1a500">
                          <SHORT-NAME>KeepPwrRsnIPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/KeepPwrRsnIPD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeepPwrRsnIPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c2000">
                          <SHORT-NAME>KeyAuthResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/KeyAuthResp_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeyAuthResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beae700">
                          <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSAFnInd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbdf100">
                          <SHORT-NAME>LADSCurToEndPntDist_LADSCurToEndPntDist_LADSCurToEndPntDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSCurToEndPntDist_LADSCurToEndPntDist_LADSCurToEndPntDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSCurToEndPntDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc10c00">
                          <SHORT-NAME>LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReqToICM_HPP</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce6500">
                          <SHORT-NAME>LADSInfoDispReqToICM_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSInfoDispReqToICM_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReqToICM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce5600">
                          <SHORT-NAME>LADSInfoDispReq_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSInfoDispReq_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bce7400">
                          <SHORT-NAME>LADSProgressBar_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LADSProgressBar_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSProgressBar</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd48b00">
                          <SHORT-NAME>LBSDAndLCAWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LBSDAndLCAWrnng_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILBSDAndLCAWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb97a00">
                          <SHORT-NAME>LCASelReq_LCASelReq_LCASelReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LCASelReq_LCASelReq_LCASelReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCASelReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd49a00">
                          <SHORT-NAME>LCASelSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LCASelSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCASelSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbcd300">
                          <SHORT-NAME>LCRInHMI_LCRInHMI_LCRInHMI</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LCRInHMI_LCRInHMI_LCRInHMI_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRInHMI</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf5900">
                          <SHORT-NAME>LCRSwDspCmd_LCRSwDspCmd_LCRSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LCRSwDspCmd_LCRSwDspCmd_LCRSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb9e300">
                          <SHORT-NAME>LCRSwReq_LCRSwReq_LCRSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LCRSwReq_LCRSwReq_LCRSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd4a900">
                          <SHORT-NAME>LDOWWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDOWWrnng_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDOWWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb3500">
                          <SHORT-NAME>LDWAdoWrnngDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWAdoWrnngDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9aa700">
                          <SHORT-NAME>LDWAdoWrnngReq_LDWAdoWrnngReq_LDWAdoWrnngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWAdoWrnngReq_LDWAdoWrnngReq_LDWAdoWrnngReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb4600">
                          <SHORT-NAME>LDWLKAAudReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKAAudReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAAudReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb5700">
                          <SHORT-NAME>LDWLKADspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKADspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKADspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb6800">
                          <SHORT-NAME>LDWLKAHptWrnngDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKAHptWrnngDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b999900">
                          <SHORT-NAME>LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_LDWLKAHptWrnngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc82b00">
                          <SHORT-NAME>LDWLKALVsulznReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKALVsulznReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKALVsulznReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc83a00">
                          <SHORT-NAME>LDWLKARVsulznReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKARVsulznReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKARVsulznReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9b1000">
                          <SHORT-NAME>LDWLKASwReq_LDWLKASwReq_LDWLKASwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKASwReq_LDWLKASwReq_LDWLKASwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKASwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc81c00">
                          <SHORT-NAME>LDWLKAVbnLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWLKAVbnLvlReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAVbnLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb7900">
                          <SHORT-NAME>LDWSnstvtLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWSnstvtLvl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b99d500">
                          <SHORT-NAME>LDWSnstvtLvlReq_LDWSnstvtLvlReq_LDWSnstvtLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWSnstvtLvlReq_LDWSnstvtLvlReq_LDWSnstvtLvlReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc84900">
                          <SHORT-NAME>LDWSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc85800">
                          <SHORT-NAME>LDWSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDWSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be43100">
                          <SHORT-NAME>LDayTimeRunningLghtCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LDayTimeRunningLghtCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDayTimeRunningLghtCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdbf200">
                          <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LFCTWrnng_ADAS_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFCTWrnng_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf4a00">
                          <SHORT-NAME>LFCTWrnng_LFCTWrnng_LFCTWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LFCTWrnng_LFCTWrnng_LFCTWrnng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFCTWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb1af00">
                          <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHSWPwrSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHSWPwrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc41100">
                          <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCUAvlbly_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUAvlbly</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c07d700">
                          <SHORT-NAME>LHZCUWKSTS_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCUWKSTS_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUWKSTS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be2d800">
                          <SHORT-NAME>LHZCU_100ms_Group30_CRC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_CRC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bde6b00">
                          <SHORT-NAME>LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_100ms_Group30</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be2e700">
                          <SHORT-NAME>LHZCU_100ms_Group30_RC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_RC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc4d00">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved103_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc5800">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved111_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc6300">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved119_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfbea00">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved12_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved12</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc6e00">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved127_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfbf500">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved23_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc0000">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved31_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc0b00">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved55_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc1600">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved63_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc2100">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved71_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc2c00">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved79_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc3700">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved87</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved87_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved87</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc4200">
                          <SHORT-NAME>LHZCU_100ms_Group30_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_Group30_Reserved95_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c1000">
                          <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_10ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c6000">
                          <SHORT-NAME>LHZCU_10ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group01_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c7000">
                          <SHORT-NAME>LHZCU_10ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group01_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c103000">
                          <SHORT-NAME>LHZCU_10ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group01_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c103b00">
                          <SHORT-NAME>LHZCU_10ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group01_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be35400">
                          <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_10ms_Group32</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be48600">
                          <SHORT-NAME>LHZCU_10ms_Group32_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be49700">
                          <SHORT-NAME>LHZCU_10ms_Group32_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fe300">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0fee00">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ff900">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c100400">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c100f00">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c101a00">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c102500">
                          <SHORT-NAME>LHZCU_10ms_Group32_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_Group32_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba66000">
                          <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_20ms_Group03</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba6d800">
                          <SHORT-NAME>LHZCU_20ms_Group03_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba6e700">
                          <SHORT-NAME>LHZCU_20ms_Group03_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c032600">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c033100">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c033c00">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c034700">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c035200">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c035d00">
                          <SHORT-NAME>LHZCU_20ms_Group03_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_Group03_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba70500">
                          <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_50ms_Group06</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba75f00">
                          <SHORT-NAME>LHZCU_50ms_Group06_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_CRC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba76e00">
                          <SHORT-NAME>LHZCU_50ms_Group06_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_RC_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c036800">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved1_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c037300">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved2_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c037e00">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved3_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c038900">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved4_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c039400">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved5_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c039f00">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved6_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03aa00">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved7_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03b500">
                          <SHORT-NAME>LHZCU_50ms_Group06_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group06_Reserved8_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf90600">
                          <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_50ms_Group24</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf9c900">
                          <SHORT-NAME>LHZCU_50ms_Group24_CRC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_CRC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf9d800">
                          <SHORT-NAME>LHZCU_50ms_Group24_RC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_RC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcfd00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved103_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd0800">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved111_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd1300">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved121</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved121_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved121</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd1e00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved135</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved135_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved135</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd2900">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved143</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved143_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved143</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd3400">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved151</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved151_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved151</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfd3f00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved159</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved159_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved159</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc7900">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved23</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved23_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved23</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc8400">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved31_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc8f00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved39_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfc9a00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved47_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcb000">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved49</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved49_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved49</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfca500">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved55_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcbb00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved60_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved60</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcc600">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved71_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcd100">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved79_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfce700">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved81</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved81_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved81</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcdc00">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved87</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved87_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved87</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfcf200">
                          <SHORT-NAME>LHZCU_50ms_Group24_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_Group24_Reserved95_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb8a00">
                          <SHORT-NAME>LKADrvrTkovReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LKADrvrTkovReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKADrvrTkovReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc75900">
                          <SHORT-NAME>LKASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LKASysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc76800">
                          <SHORT-NAME>LKASysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LKASysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba6ab00">
                          <SHORT-NAME>LMainBeamLghtCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LMainBeamLghtCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILMainBeamLghtCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd4b800">
                          <SHORT-NAME>LRCTAWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LRCTAWrnng_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILRCTAWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f1500">
                          <SHORT-NAME>Lane0_C0</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_C0_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C0</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba15600">
                          <SHORT-NAME>Lane0_C1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_C1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f7300">
                          <SHORT-NAME>Lane0_C2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_C2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0c900">
                          <SHORT-NAME>Lane0_C3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_C3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_C3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0f800">
                          <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba2bc00">
                          <SHORT-NAME>Lane0_ID</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_ID_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ID</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d6100">
                          <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_MarkerColor_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_MarkerColor</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9fe000">
                          <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_MarkerType_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_MarkerType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9cc400">
                          <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_Part0_SyncFrameIndex_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_Part0_SyncFrameIndex</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e6900">
                          <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_ViewRangeEnd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ViewRangeEnd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba24000">
                          <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_ViewRangeStart_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_ViewRangeStart</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ee600">
                          <SHORT-NAME>Lane0_location</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane0_location_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane0_location</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba29c00">
                          <SHORT-NAME>Lane1_C0</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_C0_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C0</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba14600">
                          <SHORT-NAME>Lane1_C1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_C1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ded00">
                          <SHORT-NAME>Lane1_C2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_C2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9dcd00">
                          <SHORT-NAME>Lane1_C3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_C3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_C3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f8300">
                          <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f6300">
                          <SHORT-NAME>Lane1_ID</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_ID_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ID</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ddd00">
                          <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_MarkerColor_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_MarkerColor</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba09a00">
                          <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_MarkerType_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_MarkerType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9fc100">
                          <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_Part0_SyncFrameIndex_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_Part0_SyncFrameIndex</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba1e200">
                          <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_ViewRangeEnd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ViewRangeEnd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ef600">
                          <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_ViewRangeStart_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_ViewRangeStart</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9cf300">
                          <SHORT-NAME>Lane1_location</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane1_location_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane1_location</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba00f00">
                          <SHORT-NAME>Lane2_C0</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_C0_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C0</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba22000">
                          <SHORT-NAME>Lane2_C1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_C1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba04d00">
                          <SHORT-NAME>Lane2_C2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_C2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e5900">
                          <SHORT-NAME>Lane2_C3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_C3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_C3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d0300">
                          <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba08a00">
                          <SHORT-NAME>Lane2_ID</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_ID_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ID</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9cb400">
                          <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_MarkerColor_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_MarkerColor</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9dae00">
                          <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_MarkerType_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_MarkerType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba12600">
                          <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_Part0_SyncFrameIndex_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_Part0_SyncFrameIndex</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0d900">
                          <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_ViewRangeEnd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ViewRangeEnd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e9800">
                          <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_ViewRangeStart_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_ViewRangeStart</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba03d00">
                          <SHORT-NAME>Lane2_location</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane2_location_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane2_location</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e3900">
                          <SHORT-NAME>Lane3_C0</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_C0_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C0</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba13600">
                          <SHORT-NAME>Lane3_C1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_C1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba17600">
                          <SHORT-NAME>Lane3_C2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_C2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d5100">
                          <SHORT-NAME>Lane3_C3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_C3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_C3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e4900">
                          <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9fff00">
                          <SHORT-NAME>Lane3_ID</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_ID_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ID</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ec700">
                          <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_MarkerColor_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_MarkerColor</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ea800">
                          <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_MarkerType_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_MarkerType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba1c300">
                          <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_Part0_SyncFrameIndex_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_Part0_SyncFrameIndex</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d9e00">
                          <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_ViewRangeEnd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ViewRangeEnd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0b900">
                          <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_ViewRangeStart_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_ViewRangeStart</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba28c00">
                          <SHORT-NAME>Lane3_location</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Lane3_location_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILane3_location</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbf7900">
                          <SHORT-NAME>LatSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LatSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILatSigma</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbb6800">
                          <SHORT-NAME>LatitudeRTK_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LatitudeRTK_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILatitudeRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bee0b00">
                          <SHORT-NAME>LdspcOpenSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LdspcOpenSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bee1a00">
                          <SHORT-NAME>LdspcOpenStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LdspcOpenStsV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0b0000">
                          <SHORT-NAME>LeftEyeOccludeStatus_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LeftEyeOccludeStatus_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILeftEyeOccludeStatus_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbfb000">
                          <SHORT-NAME>LonSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LonSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILonSigma</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbc0d600">
                          <SHORT-NAME>LongitudeRTK_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LongitudeRTK_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILongitudeRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b996c00">
                          <SHORT-NAME>MainBeamLghtOn_MainBeamLghtOn_MainBeamLghtOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MainBeamLghtOn_MainBeamLghtOn_MainBeamLghtOn_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be44200">
                          <SHORT-NAME>MainBeamLghtSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MainBeamLghtSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd6bc00">
                          <SHORT-NAME>MdOfPwrMd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MdOfPwrMd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMdOfPwrMd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c042a00">
                          <SHORT-NAME>MemParkngBtnRcnm_MemParkngBtnRcnm_MemParkngBtnRcnm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MemParkngBtnRcnm_MemParkngBtnRcnm_MemParkngBtnRcnm_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemParkngBtnRcnm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff9700">
                          <SHORT-NAME>MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSlntPtrlEnbSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bffd300">
                          <SHORT-NAME>MemPkngSlntPtrlEnbSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MemPkngSlntPtrlEnbSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSlntPtrlEnbSwResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bffa600">
                          <SHORT-NAME>MemPkngSwReq_MemPkngSwReq_MemPkngSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MemPkngSwReq_MemPkngSwReq_MemPkngSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bffe200">
                          <SHORT-NAME>MemPkngSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MemPkngSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSwResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb23fcb00">
                          <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MnvrngPntDistNav_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMnvrngPntDistNav</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb2410b00">
                          <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MnvrngPntTypNav_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMnvrngPntTypNav</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0b3000">
                          <SHORT-NAME>MouthOccludeStatus_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/MouthOccludeStatus_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMouthOccludeStatus_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc00d00">
                          <SHORT-NAME>NOACitySysMsg_NOACitySysMsg_NOACitySysMsg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOACitySysMsg_NOACitySysMsg_NOACitySysMsg_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOACitySysMsg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc7900">
                          <SHORT-NAME>NOADistDecMsg_NOADistDecMsg_NOADistDecMsg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOADistDecMsg_NOADistDecMsg_NOADistDecMsg_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOADistDecMsg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc18400">
                          <SHORT-NAME>NOAETCSetDspCmd_NOAETCSetDspCmd_NOAETCSetDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAETCSetDspCmd_NOAETCSetDspCmd_NOAETCSetDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAETCSetDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb8c600">
                          <SHORT-NAME>NOAETCSetSwReq_NOAETCSetSwReq_NOAETCSetSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAETCSetSwReq_NOAETCSetSwReq_NOAETCSetSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAETCSetSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc14800">
                          <SHORT-NAME>NOALaneSetDspCmd_NOALaneSetDspCmd_NOALaneSetDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOALaneSetDspCmd_NOALaneSetDspCmd_NOALaneSetDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOALaneSetDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbab500">
                          <SHORT-NAME>NOALaneSetSwReq_NOALaneSetSwReq_NOALaneSetSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOALaneSetSwReq_NOALaneSetSwReq_NOALaneSetSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOALaneSetSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc0e00">
                          <SHORT-NAME>NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_NOAQukChgSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAQukChgSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb89900">
                          <SHORT-NAME>NOAQukChgSwReq_NOAQukChgSwReq_NOAQukChgSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAQukChgSwReq_NOAQukChgSwReq_NOAQukChgSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAQukChgSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf6800">
                          <SHORT-NAME>NOAReportSetDspCmd_NOAReportSetDspCmd_NOAReportSetDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAReportSetDspCmd_NOAReportSetDspCmd_NOAReportSetDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAReportSetDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb85d00">
                          <SHORT-NAME>NOAReportSetSwReq_NOAReportSetSwReq_NOAReportSetSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOAReportSetSwReq_NOAReportSetSwReq_NOAReportSetSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAReportSetSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbec300">
                          <SHORT-NAME>NOPCitySwDspCmd_NOPCitySwDspCmd_NOPCitySwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPCitySwDspCmd_NOPCitySwDspCmd_NOPCitySwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPCitySwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb95c00">
                          <SHORT-NAME>NOPCitySwReq_NOPCitySwReq_NOPCitySwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPCitySwReq_NOPCitySwReq_NOPCitySwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPCitySwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc1a200">
                          <SHORT-NAME>NOPSwDspCmd_NOPSwDspCmd_NOPSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPSwDspCmd_NOPSwDspCmd_NOPSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb93e00">
                          <SHORT-NAME>NOPSwReq_NOPSwReq_NOPSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPSwReq_NOPSwReq_NOPSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd9400">
                          <SHORT-NAME>NOPSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc1cf00">
                          <SHORT-NAME>NOPSysMsg_NOPSysMsg_NOPSysMsg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPSysMsg_NOPSysMsg_NOPSysMsg_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysMsg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdda400">
                          <SHORT-NAME>NOPSysSts_ZPD_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NOPSysSts_ZPD_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysSts_ZPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc1f00">
                          <SHORT-NAME>NSABacSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NSABacSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSABacSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc2e00">
                          <SHORT-NAME>NSADisFucSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NSADisFucSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSADisFucSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc3d00">
                          <SHORT-NAME>NSAForSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NSAForSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSAForSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc4c00">
                          <SHORT-NAME>NSAReqAVMDis_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NSAReqAVMDis_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSAReqAVMDis</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba4c00">
                          <SHORT-NAME>NarRoVslAssQuit_NarRoVslAssQuit_NarRoVslAssQuit</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarRoVslAssQuit_NarRoVslAssQuit_NarRoVslAssQuit_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssQuit</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb84e00">
                          <SHORT-NAME>NarRoVslAssSwReq_NarRoVslAssSwReq_NarRoVslAssSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarRoVslAssSwReq_NarRoVslAssSwReq_NarRoVslAssSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc0ee00">
                          <SHORT-NAME>NarRoVslAssSwResp_NarRoVslAssSwResp_NarRoVslAssSwResp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarRoVslAssSwResp_NarRoVslAssSwResp_NarRoVslAssSwResp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssSwResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbfc200">
                          <SHORT-NAME>NarrowRoadBackwardSts_NarrowRoadBackwardSts_NarrowRoadBackwardSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarrowRoadBackwardSts_NarrowRoadBackwardSts_NarrowRoadBackwardSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarrowRoadBackwardSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbed200">
                          <SHORT-NAME>NarrowRoadForwardSts_NarrowRoadForwardSts_NarrowRoadForwardSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarrowRoadForwardSts_NarrowRoadForwardSts_NarrowRoadForwardSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarrowRoadForwardSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbdd300">
                          <SHORT-NAME>NarwSpcAstBtnSts_NarwSpcAstBtnSts_NarwSpcAstBtnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarwSpcAstBtnSts_NarwSpcAstBtnSts_NarwSpcAstBtnSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarwSpcAstBtnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb90200">
                          <SHORT-NAME>NarwSpcAstSwReq_NarwSpcAstSwReq_NarwSpcAstSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NarwSpcAstSwReq_NarwSpcAstSwReq_NarwSpcAstSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarwSpcAstSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd6ab00">
                          <SHORT-NAME>NavCndSpdLmtVal_NavCndSpdLmtVal_NavCndSpdLmtVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavCndSpdLmtVal_NavCndSpdLmtVal_NavCndSpdLmtVal_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavCndSpdLmtVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb88a00">
                          <SHORT-NAME>NavCrntRoadTyp_NavCrntRoadTyp_NavCrntRoadTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavCrntRoadTyp_NavCrntRoadTyp_NavCrntRoadTyp_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavCrntRoadTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd71400">
                          <SHORT-NAME>NavCtryCode_ISO_NavCtryCode_ISO_NavCtryCode_ISO</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavCtryCode_ISO_NavCtryCode_ISO_NavCtryCode_ISO_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavCtryCode_ISO</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbb1e00">
                          <SHORT-NAME>NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_NavDistFromFrtEleccEye</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavDistFromFrtEleccEye</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb8d500">
                          <SHORT-NAME>NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavItvalSpdDetnDistRetDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb83f00">
                          <SHORT-NAME>NavNewIconDist_NavNewIconDist_NavNewIconDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavNewIconDist_NavNewIconDist_NavNewIconDist_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavNewIconDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd72300">
                          <SHORT-NAME>NavNextRampOffset_NavNextRampOffset_NavNextRampOffset</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavNextRampOffset_NavNextRampOffset_NavNextRampOffset_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavNextRampOffset</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbb0000">
                          <SHORT-NAME>NavSpdLmtTyp_NavSpdLmtTyp_NavSpdLmtTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavSpdLmtTyp_NavSpdLmtTyp_NavSpdLmtTyp_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavSpdLmtTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd74100">
                          <SHORT-NAME>NavSpdLmtValSts_NavSpdLmtValSts_NavSpdLmtValSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavSpdLmtValSts_NavSpdLmtValSts_NavSpdLmtValSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavSpdLmtValSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba2e00">
                          <SHORT-NAME>NavSpdLmtValUnit_NavSpdLmtValUnit_NavSpdLmtValUnit</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavSpdLmtValUnit_NavSpdLmtValUnit_NavSpdLmtValUnit_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavSpdLmtValUnit</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd6ba00">
                          <SHORT-NAME>NavSpdLmtVal_NavSpdLmtVal_NavSpdLmtVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavSpdLmtVal_NavSpdLmtVal_NavSpdLmtVal_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavSpdLmtVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2ce00">
                          <SHORT-NAME>NavSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NavSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INavSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d8f00">
                          <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NonDirectDMSSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9b0100">
                          <SHORT-NAME>NonDirectDMSSwReq_NonDirectDMSSwReq_NonDirectDMSSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NonDirectDMSSwReq_NonDirectDMSSwReq_NonDirectDMSSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c9600">
                          <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NonDirectDMSSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba7c800">
                          <SHORT-NAME>NorthVelocityRTK_NorthVelocityRTK_NorthVelocityRTK</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NorthVelocityRTK_NorthVelocityRTK_NorthVelocityRTK_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INorthVelocityRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc1b100">
                          <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssConfrmSwDscmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbaf100">
                          <SHORT-NAME>NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssConfrmSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd9700">
                          <SHORT-NAME>NrwroadBwdAssMesg_NrwroadBwdAssMesg_NrwroadBwdAssMesg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadBwdAssMesg_NrwroadBwdAssMesg_NrwroadBwdAssMesg_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssMesg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba9700">
                          <SHORT-NAME>NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_NrwroadBwdAssSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbe0f00">
                          <SHORT-NAME>NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_NrwroadBwdAssSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc12a00">
                          <SHORT-NAME>NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_NrwroadFwdBtnDsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdBtnDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd5b00">
                          <SHORT-NAME>NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_NrwroadFwdCndNotSt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdCndNotSt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb9c500">
                          <SHORT-NAME>NrwroadFwdCtlReq_NrwroadFwdCtlReq_NrwroadFwdCtlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdCtlReq_NrwroadFwdCtlReq_NrwroadFwdCtlReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdCtlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc5b00">
                          <SHORT-NAME>NrwroadFwdDsp_NrwroadFwdDsp_NrwroadFwdDsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDsp_NrwroadFwdDsp_NrwroadFwdDsp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc01c00">
                          <SHORT-NAME>NrwroadFwdDst360Req_NrwroadFwdDst360Req_NrwroadFwdDst360Req</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDst360Req_NrwroadFwdDst360Req_NrwroadFwdDst360Req_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDst360Req</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc21a00">
                          <SHORT-NAME>NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstBtnDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd0000">
                          <SHORT-NAME>NrwroadFwdDstL_NrwroadFwdDstL_NrwroadFwdDstL</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDstL_NrwroadFwdDstL_NrwroadFwdDstL_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstL</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc08500">
                          <SHORT-NAME>NrwroadFwdDstR_NrwroadFwdDstR_NrwroadFwdDstR</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDstR_NrwroadFwdDstR_NrwroadFwdDstR_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstR</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf8600">
                          <SHORT-NAME>NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdDstTostDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd2e00">
                          <SHORT-NAME>NrwroadFwdReDst_NrwroadFwdReDst_NrwroadFwdReDst</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdReDst_NrwroadFwdReDst_NrwroadFwdReDst_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdReDst</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbad300">
                          <SHORT-NAME>NrwroadFwdReq_NrwroadFwdReq_NrwroadFwdReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdReq_NrwroadFwdReq_NrwroadFwdReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc1d00">
                          <SHORT-NAME>NrwroadFwdSta_NrwroadFwdSta_NrwroadFwdSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdSta_NrwroadFwdSta_NrwroadFwdSta_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbee100">
                          <SHORT-NAME>NrwroadFwdSwSts_NrwroadFwdSwSts_NrwroadFwdSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadFwdSwSts_NrwroadFwdSwSts_NrwroadFwdSwSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb8b700">
                          <SHORT-NAME>NrwroadsltReq_NrwroadsltReq_NrwroadsltReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadsltReq_NrwroadsltReq_NrwroadsltReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadsltReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc2d00">
                          <SHORT-NAME>NrwroadsltSta_NrwroadsltSta_NrwroadsltSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NrwroadsltSta_NrwroadsltSta_NrwroadsltSta_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadsltSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c09e000">
                          <SHORT-NAME>OMSSts_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OMSSts_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOMSSts_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beffa00">
                          <SHORT-NAME>OdoPriyPrcs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OdoPriyPrcs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf00900">
                          <SHORT-NAME>OdoPriyPrcsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OdoPriyPrcsV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb15500">
                          <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OtsdAirTemCrVal_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb87b00">
                          <SHORT-NAME>OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_OtsdAirTemCrValMsk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrValMsk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb12800">
                          <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/OtsdAirTemCrValV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrValV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd6f200">
                          <SHORT-NAME>PDCSwReq_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/PDCSwReq_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDCSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbeb400">
                          <SHORT-NAME>PDCSysSts_PDCSysSts_PDCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/PDCSysSts_PDCSysSts_PDCSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbe8700">
                          <SHORT-NAME>PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_PDSysKeyPsAvlbl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDSysKeyPsAvlbl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf9500">
                          <SHORT-NAME>PEBSts_PEBSts_PEBSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
