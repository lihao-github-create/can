                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFUpdtInd_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtInd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb965b00">
                  <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFWrnngMdResp/SLIFWrnngMdResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFWrnngMdResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbaea00">
                  <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdAstCndStsCamr/SpdAstCndStsCamr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdAstCndStsCamr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstCndStsCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb409d00">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdAstSysTrgtSpd_IPD/SpdAstSysTrgtSpd_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdAstSysTrgtSpd_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstSysTrgtSpd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb40c000">
                  <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLimitManualSts/SpdLimitManualSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLimitManualSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLimitManualSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb40e300">
                  <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtMdMsgReq/SpdLmtMdMsgReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtMdMsgReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb410600">
                  <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtMdResp/SpdLmtMdResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtMdResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb412900">
                  <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumResp/SpdLmtOfstSetNumResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetNumResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb414c00">
                  <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercResp/SpdLmtOfstSetPercResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetPercResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb416f00">
                  <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetResp/SpdLmtOfstSetResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetResp</SHORT-LABEL>
                          <VALUE>0x14</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb764200">
                  <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpedRegulaModSwSts/SpedRegulaModSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpedRegulaModSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb419200">
                  <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TJAICAMsgReq/TJAICAMsgReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TJAICAMsgReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TJAICAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb41b500">
                  <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMdSwDspCmd/TLRMdSwDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TLRMdSwDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb41d800">
                  <SHORT-NAME>TLRMsgReq</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMsgReq/TLRMsgReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TLRMsgReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb41fb00">
                  <SHORT-NAME>TLRSysSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRSysSts/TLRSysSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TLRSysSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb421e00">
                  <SHORT-NAME>TLRWarning</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRWarning/TLRWarning</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TLRWarning</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRWarning</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb424100">
                  <SHORT-NAME>TSRSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSts/TSRSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TSRSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb426400">
                  <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSwReqResp/TSRSwReqResp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TSRSwReqResp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReqResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb428700">
                  <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRTrgtBanSign/TSRTrgtBanSign</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TSRTrgtBanSign</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtBanSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb42aa00">
                  <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRTrgtWarnSign/TSRTrgtWarnSign</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TSRTrgtWarnSign</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtWarnSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8a6500">
                  <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TgtParkingFavorite/TgtParkingFavorite</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TgtParkingFavorite</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TgtParkingFavorite</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb42cd00">
                  <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ToEPSMsgChlg/ToEPSMsgChlg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ToEPSMsgChlg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ToEPSMsgChlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb798a00">
                  <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfGreenLghtActn/TrfGreenLghtActn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfGreenLghtActn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfGreenLghtActn</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb787200">
                  <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwSts/TrfcLghtFuctionSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcLghtFuctionSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb789500">
                  <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtStSp/TrfcLghtStSp</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcLghtStSp</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtStSp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb78b800">
                  <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdForbidDist/TrfcMrgdForbidDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdForbidDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb78db00">
                  <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdForbidSign/TrfcMrgdForbidSign</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdForbidSign</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb78fe00">
                  <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSign/TrfcMrgdInfoSign</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdInfoSign</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb792100">
                  <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSignDist/TrfcMrgdInfoSignDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdInfoSignDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb794400">
                  <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSign/TrfcMrgdWrnngSign</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdWrnngSign</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb796700">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSignDist/TrfcMrgdWrnngSignDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcMrgdWrnngSignDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbac600">
                  <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrgtCndSpdReqCamr/TrgtCndSpdReqCamr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrgtCndSpdReqCamr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtCndSpdReqCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb967e00">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <PROVIDED-COM-SPECS>
                    <NONQUEUED-SENDER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrgtSpdSrcSts_IPD/TrgtSpdSrcSts_IPD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrgtSpdSrcSts_IPD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-SENDER-COM-SPEC>
                  </PROVIDED-COM-SPECS>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtSpdSrcSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb27b200">
                  <SHORT-NAME>ACCConfmSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCConfmSwReq/ACCConfmSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ACCConfmSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCConfmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb27d900">
                  <SHORT-NAME>ACCCurveSpdSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCCurveSpdSwReq/ACCCurveSpdSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ACCCurveSpdSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCCurveSpdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb280000">
                  <SHORT-NAME>ACCSpdLimtSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCSpdLimtSwReq/ACCSpdLimtSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ACCSpdLimtSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb282700">
                  <SHORT-NAME>ACCStsSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCStsSwReq/ACCStsSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ACCStsSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb284e00">
                  <SHORT-NAME>ACCTJAMdSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCTJAMdSwReq/ACCTJAMdSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ACCTJAMdSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCTJAMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb287500">
                  <SHORT-NAME>ADAudioSWReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADAudioSWReq/ADAudioSWReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ADAudioSWReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADAudioSWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb289c00">
                  <SHORT-NAME>AEBSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250207_ANB智驾L2+信号需求_20241127.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AEBSwReq/AEBSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AEBSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb92e300">
                  <SHORT-NAME>AIParkngEPAMdsw</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngEPAMdsw/AIParkngEPAMdsw</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngEPAMdsw</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngEPAMdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb60f000">
                  <SHORT-NAME>AIParkngReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReq/AIParkngReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7a6800">
                  <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250611_IP5PM EP信号需求V7-梳理.xlsx
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReqICB/AIParkngReqICB</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngReqICB</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReqICB</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb60c900">
                  <SHORT-NAME>AIParkngReq_ZXD</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReq_ZXD/AIParkngReq_ZXD</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngReq_ZXD</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq_ZXD</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba24f00">
                  <SHORT-NAME>AIParkngSSPLotSw</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSSPLotSw/AIParkngSSPLotSw</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngSSPLotSw</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSSPLotSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb65a400">
                  <SHORT-NAME>AIParkngSpcID</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSpcID/AIParkngSpcID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngSpcID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpcID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb68fe00">
                  <SHORT-NAME>AIParkngSpdsw</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSpdsw/AIParkngSpdsw</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AIParkngSpdsw</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb657d00">
                  <SHORT-NAME>APAOneKeyParkSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APAOneKeyParkSwReq/APAOneKeyParkSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>APAOneKeyParkSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAOneKeyParkSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb688900">
                  <SHORT-NAME>APAParkInOffsetTypeReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APAParkInOffsetTypeReq/APAParkInOffsetTypeReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>APAParkInOffsetTypeReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAParkInOffsetTypeReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb683b00">
                  <SHORT-NAME>APASWReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APASWReq/APASWReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>APASWReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb661900">
                  <SHORT-NAME>AVMDspReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVMDspReq/AVMDspReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AVMDspReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMDspReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb664000">
                  <SHORT-NAME>AVMSt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVMSt/AVMSt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AVMSt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMSt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbae1a00">
                  <SHORT-NAME>AVPMapRutMgIDtReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx
20260528_新增接收2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVPMapRutMgIDtReq/AVPMapRutMgIDtReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AVPMapRutMgIDtReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVPMapRutMgIDtReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb641e00">
                  <SHORT-NAME>AutoLaneChngSetReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngSetReq/AutoLaneChngSetReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AutoLaneChngSetReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb63f700">
                  <SHORT-NAME>AutoLaneChngSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngSwReq/AutoLaneChngSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AutoLaneChngSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb644500">
                  <SHORT-NAME>AutoLaneChngVcCmd</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngVcCmd/AutoLaneChngVcCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AutoLaneChngVcCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngVcCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2bf600">
                  <SHORT-NAME>AutoMainBeamLghtOn</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241128_副本总表_0.5_20241127.xlsx
20250704_工作簿3.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoMainBeamLghtOn/AutoMainBeamLghtOn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>AutoMainBeamLghtOn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoMainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb630d00">
                  <SHORT-NAME>BSDSelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/BSDSelReq/BSDSelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>BSDSelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BSDSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb49db00">
                  <SHORT-NAME>BaseLineLen</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/BaseLineLen/BaseLineLen</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>BaseLineLen</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BaseLineLen</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4a0200">
                  <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CANprotocolinternalversion/CANprotocolinternalversion</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>CANprotocolinternalversion</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CANprotocolinternalversion</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb79f300">
                  <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250611_IP5PM EP信号需求V7-梳理.xlsx_HVDCDCTem
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_HVDCDCTem
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_HVDCDCSta
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_HVDCDCTem
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_HVDCDCSta
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_HVDCDCTem</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group02/CCU_100ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>CCU_100ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCDCSta</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCDCTem</SHORT-LABEL>
                              <VALUE>0xfe</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCHVILStsV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrHVILStsVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrHVILStsValV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PDUHVILSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PDUHVILStsV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCHVILSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group02_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxOa505a3f19f25843c4ba378a200">
                  <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260703_modify.xlsx_CCUActiveWkup
20260703_modify.xlsx_CCUOnbdChrgrMaxChrgPwr
20260703_modify.xlsx_CCUOnbdChrgrPlugOn
20260703_modify.xlsx_CCUOnbdChrgrPlugOnV
20260703_modify.xlsx_CCUOnbdChrgrSpRsn
20260703_modify.xlsx_CCU_100ms_Group07_CRC
20260703_modify.xlsx_CCU_100ms_Group07_RC
20260703_modify.xlsx_CCU_100ms_Group07_Reserved1
20260703_modify.xlsx_CCU_100ms_Group07_Reserved10
20260703_modify.xlsx_CCU_100ms_Group07_Reserved11
20260703_modify.xlsx_CCU_100ms_Group07_Reserved2
20260703_modify.xlsx_CCU_100ms_Group07_Reserved3
20260703_modify.xlsx_CCU_100ms_Group07_Reserved4
20260703_modify.xlsx_CCU_100ms_Group07_Reserved5
20260703_modify.xlsx_CCU_100ms_Group07_Reserved6
20260703_modify.xlsx_CCU_100ms_Group07_Reserved7
20260703_modify.xlsx_CCU_100ms_Group07_Reserved8
20260703_modify.xlsx_CCU_100ms_Group07_Reserved9
20260703_modify.xlsx_OnBdChrgrAltrCrntInptCrnt
20260703_modify.xlsx_OnBdChrgrAltrCrntInptVol
20260703_modify.xlsx_OnBdChrgrCtrlPilotPWMDuty
20260703_modify.xlsx_OnBdChrgrCtrlPilotPWMSts
20260703_modify.xlsx_OnBdChrgrL1AltrCrntInptCrnt
20260703_modify.xlsx_OnBdChrgrL1AltrCrntInptVol
20260703_modify.xlsx_OnBdChrgrL2AltrCrntInptCrnt
20260703_modify.xlsx_OnBdChrgrL2AltrCrntInptVol
20260703_modify.xlsx_OnBdChrgrL3AltrCrntInptCrnt
20260703_modify.xlsx_OnBdChrgrL3AltrCrntInptVol
20260703_modify.xlsx_OnBdChrgrLastWkup
20260703_modify.xlsx_OnBdChrgrOtptVolV
20260703_modify.xlsx_OnBdChrgrSts
20260703_modify.xlsx_OnBdChrgrWkup
20260703_modify.xlsx_OnbdChrgrAltrCrntInptHVCrntLmt
20260703_modify.xlsx_OnbdChrgrOpngMd
20260703_modify.xlsx_OnbdChrgrOtptCrntV
20260703_modify.xlsx_OnbdChrgrOtptCrntVal
20260703_modify.xlsx_OnbdChrgrOtptVolVal
20260707_modify.xlsx_CCUOnbdChrgrMaxChrgPwr</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group07/CCU_100ms_Group07</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>CCU_100ms_Group07</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUActiveWkup</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUOnbdChrgrMaxChrgPwr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUOnbdChrgrPlugOn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUOnbdChrgrPlugOnV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUOnbdChrgrSpRsn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved10</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved2</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved3</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved4</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved5</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved6</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved8</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group07_Reserved9</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrAltrCrntInptCrnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrAltrCrntInptVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrCtrlPilotPWMDuty</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrCtrlPilotPWMSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL1AltrCrntInptCrnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL1AltrCrntInptVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL2AltrCrntInptCrnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL2AltrCrntInptVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL3AltrCrntInptCrnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrL3AltrCrntInptVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrLastWkup</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrOtptVolV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnBdChrgrWkup</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrAltrCrntInptHVCrntLmt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrOpngMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrOtptCrntV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrOtptCrntVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OnbdChrgrOtptVolVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8ddd00">
                  <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250701_工作簿1.xlsx_CCUEleccLckCtrlDspCmd</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCU_100ms_Group11/CCU_100ms_Group11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>CCU_100ms_Group11</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirCtrlrHVILClsd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AirCtrlrHVILClsdV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUClntFlowReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCUOnbdChrgrSktEleccLckEnable</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSPTCHVILSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESSPTCHVILStsV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCDCClntPumpPWMReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCDCHdwrFlr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HVDCDCIntnlFlr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved4</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved6</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved11</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved12</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved13</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CCU_100ms_Group11_Reserved14</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ca900">
                  <SHORT-NAME>ChrgPwrReq_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ChrgPwrReq_kW/ChrgPwrReq_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ChrgPwrReq_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgPwrReq_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7cd000">
                  <SHORT-NAME>ChrgReq_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ChrgReq_flg/ChrgReq_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ChrgReq_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb92bc00">
                  <SHORT-NAME>ClstrDspdVehSpd_mph</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260706_modify.xlsx
20260715_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ClstrDspdVehSpd_mph/ClstrDspdVehSpd_mph</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ClstrDspdVehSpd_mph</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ClstrDspdVehSpd_mph</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5f6800">
                  <SHORT-NAME>ComKeyEnbReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx
20260528_新增接收2.xlsx
20260706_modify.xlsx
20260707_modify.xlsx
20260715_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ComKeyEnbReq/ComKeyEnbReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ComKeyEnbReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ComKeyEnbReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb933100">
                  <SHORT-NAME>D2DPriETClanSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DPriETClanSwReq/D2DPriETClanSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>D2DPriETClanSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DPriETClanSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb930a00">
                  <SHORT-NAME>D2DSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DSwReq/D2DSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>D2DSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7cf700">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_0/DFC_Current_DisplyBuffer_0</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DFC_Current_DisplyBuffer_0</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_0</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7d1e00">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_1/DFC_Current_DisplyBuffer_1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DFC_Current_DisplyBuffer_1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7d4500">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_2/DFC_Current_DisplyBuffer_2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DFC_Current_DisplyBuffer_2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbb2a600">
                  <SHORT-NAME>DMSCameraFps_IMM</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260528_AS5PMCAN需求导入表.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DMSCameraFps_IMM/DMSCameraFps_IMM</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DMSCameraFps_IMM</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DMSCameraFps_IMM</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb638200">
                  <SHORT-NAME>DOWSelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DOWSelReq/DOWSelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DOWSelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DOWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbacc300">
                  <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DfstOnDspCmd/DfstOnDspCmd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DfstOnDspCmd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DfstOnDspCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4a2900">
                  <SHORT-NAME>DiffAgeInfo</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DiffAgeInfo/DiffAgeInfo</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DiffAgeInfo</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffAgeInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4a5000">
                  <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DiffDataLinkBroken/DiffDataLinkBroken</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DiffDataLinkBroken</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffDataLinkBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb491900">
                  <SHORT-NAME>DircnIndLghtMdSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250521_IP5PM EP信号需求V1-输出.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DircnIndLghtMdSts/DircnIndLghtMdSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DircnIndLghtMdSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtMdSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb271600">
                  <SHORT-NAME>DircnIndLghtSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241118_副本总表_0.3_20241118.xlsx
20250207_ANB智驾L2+信号需求_20241127.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DircnIndLghtSwSts/DircnIndLghtSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DircnIndLghtSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb2386500">
                  <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DistToTrfcJamNav/DistToTrfcJamNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DistToTrfcJamNav</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DistToTrfcJamNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4a7700">
                  <SHORT-NAME>DownVelocityRTK</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DownVelocityRTK/DownVelocityRTK</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DownVelocityRTK</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DownVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7d6c00">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlFilt_Nm/DrvTqReqWhlFilt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DrvTqReqWhlFilt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlFilt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7d9300">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlRawCap_Nm/DrvTqReqWhlRawCap_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DrvTqReqWhlRawCap_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRawCap_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7dba00">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlRaw_Nm/DrvTqReqWhlRaw_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DrvTqReqWhlRaw_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRaw_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb629900">
                  <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260703_modify.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvrDstrctnSts/DrvrDstrctnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DrvrDstrctnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrDstrctnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb62c000">
                  <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260506_20260506-AS5PR EV-PPV-V1.2.xlsx
20260528_新增接收.xlsx
20260703_modify.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvrFtgLvl/DrvrFtgLvl</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DrvrFtgLvl</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7de100">
                  <SHORT-NAME>DsblICE_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DsblICE_flg/DsblICE_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DsblICE_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblICE_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7e0800">
                  <SHORT-NAME>DsblISG_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DsblISG_flg/DsblISG_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DsblISG_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblISG_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbbb5900">
                  <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260601_修改2.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DschrgOptMaxPwr/DschrgOptMaxPwr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>DschrgOptMaxPwr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DschrgOptMaxPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9f0400">
                  <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251222_D5X-接收网段-2025-12-22.xlsx_ClOpenReqA
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_010ms_Group00_CRC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_010ms_Group00_RC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_010ms_Group00_Reserved1
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_010ms_Group00_Reserved2
20251222_D5X-接收网段-2025-12-22.xlsx_EnActuStdyStaToq
20251222_D5X-接收网段-2025-12-22.xlsx_EnActuStdyStaToqV
20251222_D5X-接收网段-2025-12-22.xlsx_EnCCMd
20251222_D5X-接收网段-2025-12-22.xlsx_EnCtrlrRunCrkTrmlSts
20251222_D5X-接收网段-2025-12-22.xlsx_EnRunA
20251222_D5X-接收网段-2025-12-22.xlsx_EnSpReqToTr
20251222_D5X-接收网段-2025-12-22.xlsx_EnSpd
20251222_D5X-接收网段-2025-12-22.xlsx_EnSpdSts
20251222_D5X-接收网段-2025-12-22.xlsx_IntlckRelayAuth
20251222_D5X-接收网段-2025-12-22.xlsx_RVSPtCrkAbotd
20251222_D5X-接收网段-2025-12-22.xlsx_RVSPtRunAbotd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EnRunA
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnTestMdEnbReq
20260706_modify.xlsx_EnSpd
20260720_C1.xlsx_ClOpenReqA
20260720_C1.xlsx_ECM_010ms_Group00_CRC
20260720_C1.xlsx_ECM_010ms_Group00_RC
20260720_C1.xlsx_ECM_010ms_Group00_Reserved39
20260720_C1.xlsx_ECM_010ms_Group00_Reserved63
20260720_C1.xlsx_EnActuStdyStaToq
20260720_C1.xlsx_EnActuStdyStaToqV
20260720_C1.xlsx_EnCCMd
20260720_C1.xlsx_EnCtrlrRunCrkTrmlSts
20260720_C1.xlsx_EnRunA
20260720_C1.xlsx_EnSpReqToTr
20260720_C1.xlsx_EnSpd
20260720_C1.xlsx_EnSpdSts
20260720_C1.xlsx_EnTestMdEnbReq
20260720_C1.xlsx_IntlckRelayAuth
20260720_C1.xlsx_RVSPtCrkAbotd
20260720_C1.xlsx_RVSPtRunAbotd</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_010ms_Group00/ECM_010ms_Group00</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ECM_010ms_Group00</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_010ms_Group00_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_010ms_Group00_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnActuStdyStaToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnActuStdyStaToqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnRunA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnSpd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnSpdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnCCMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ClOpenReqA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnCtrlrRunCrkTrmlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnSpReqToTr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IntlckRelayAuth</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RVSPtCrkAbotd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RVSPtRunAbotd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnTestMdEnbReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_010ms_Group00_Reserved39</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_010ms_Group00_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_010ms_Group00</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f8230bf8d463e000">
                  <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260721_C1.xlsx_AutocTrGearShftDircn
20260721_C1.xlsx_AutocTrGearShftDircnF
20260721_C1.xlsx_DrvlnToqStabSts
20260721_C1.xlsx_ECM_25ms_Group36_CRC
20260721_C1.xlsx_ECM_25ms_Group36_RC
20260721_C1.xlsx_ECM_25ms_Group36_Reserved1
20260721_C1.xlsx_ECM_25ms_Group36_Reserved10
20260721_C1.xlsx_ECM_25ms_Group36_Reserved2
20260721_C1.xlsx_ECM_25ms_Group36_Reserved3
20260721_C1.xlsx_ECM_25ms_Group36_Reserved4
20260721_C1.xlsx_ECM_25ms_Group36_Reserved5
20260721_C1.xlsx_ECM_25ms_Group36_Reserved6
20260721_C1.xlsx_ECM_25ms_Group36_Reserved7
20260721_C1.xlsx_ECM_25ms_Group36_Reserved8
20260721_C1.xlsx_ECM_25ms_Group36_Reserved9
20260721_C1.xlsx_TrCrkshftToqLd
20260721_C1.xlsx_TrCrkshftToqLdV
20260721_C1.xlsx_TrCustSetngDspCmd
20260721_C1.xlsx_TrEnASSOvrd
20260721_C1.xlsx_TrInptClStsV_ICE
20260721_C1.xlsx_TrInptClSts_ICE
20260721_C1.xlsx_TrMinVolReq
20260721_C1.xlsx_TrRngInhSts
20260721_C1.xlsx_TrWrnngDsp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_25ms_Group36/ECM_25ms_Group36</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ECM_25ms_Group36</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrInptClSts_ICE</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrInptClStsV_ICE</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutocTrGearShftDircn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutocTrGearShftDircnF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvlnToqStabSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrCrkshftToqLd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrCrkshftToqLdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrCustSetngDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEnASSOvrd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrMinVolReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrRngInhSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrWrnngDsp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_25ms_Group36_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_25ms_Group36</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba55900">
                  <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_BarPrsAbs
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_BarPrsAbsOBD
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_BarPrsAbsV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ECM_500ms_group02_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_ECM_500ms_group02_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnClntTem
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnClntTemV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnIntkAirTem
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnIntkAirTemV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_EnWarmUpCycAch
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OtsdAirTemPtEstd
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OtsdAirTemPtEstdMsk
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_OtsdAirTemPtEstdV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_TrClThrmlProtnNotfn_ECM
20260528_新增接收.xlsx_EnWarmUpCycAch
20260601_修改1.xlsx_EnWarmUpCycAch
20260601_修改1.xlsx_OtsdAirTemPtEstd
20260601_修改1.xlsx_OtsdAirTemPtEstdMsk
20260601_修改1.xlsx_OtsdAirTemPtEstdV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_500ms_group02/ECM_500ms_group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ECM_500ms_group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BarPrsAbs</SHORT-LABEL>
                              <VALUE>0xc8</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BarPrsAbsOBD</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BarPrsAbsV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnClntTem</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnClntTemV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnIntkAirTem</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnIntkAirTemV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnWarmUpCycAch</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OtsdAirTemPtEstd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OtsdAirTemPtEstdMsk</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>OtsdAirTemPtEstdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_500ms_group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_500ms_group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrClThrmlProtnNotfn_ECM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_500ms_group02_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_500ms_group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9f2b00">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251222_D5X-接收网段-2025-12-22.xlsx_ECM_020ms_PDU03_CRC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_020ms_PDU03_RC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_020ms_Group03_Reserved1
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_020ms_Group03_Reserved2
20251222_D5X-接收网段-2025-12-22.xlsx_EnASSFrngDet
20251222_D5X-接收网段-2025-12-22.xlsx_EnASSFuelReqdOn
20251222_D5X-接收网段-2025-12-22.xlsx_EnASSSta
20251222_D5X-接收网段-2025-12-22.xlsx_EnASSStallDet
20251222_D5X-接收网段-2025-12-22.xlsx_EnAutoSpNotProb
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqActuExtdRng
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqActuExtdRngV
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqDrvrReqdExtdRng
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqDrvrReqdExtdRngV
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqRducnFlrSts
20251222_D5X-接收网段-2025-12-22.xlsx_PropSysA
20260706_modify.xlsx_EnToqActuExtdRng</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_ZONE_020ms_Group03/ECM_ZONE_020ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ECM_ZONE_020ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnASSFrngDet</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnASSFuelReqdOn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnASSStallDet</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnAutoSpNotProb</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqActuExtdRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqActuExtdRngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqDrvrReqdExtdRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqDrvrReqdExtdRngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqRducnFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PropSysA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_020ms_PDU03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_020ms_PDU03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnASSSta</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_020ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_020ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_020ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9f5200">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_050ms_Group09_CRC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_050ms_Group09_RC
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_050ms_Group09_Reserved1
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_050ms_Group09_Reserved2
20251222_D5X-接收网段-2025-12-22.xlsx_ECM_ZONE_050ms_Group09_Reserved3
20251222_D5X-接收网段-2025-12-22.xlsx_ECODrvngSpdRutA
20251222_D5X-接收网段-2025-12-22.xlsx_EcoDrvngAIO
20251222_D5X-接收网段-2025-12-22.xlsx_EcoDrvngDspStsGearShftIndSts
20251222_D5X-接收网段-2025-12-22.xlsx_EcoDrvngDspStsRcmndFwdGear
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqMaxExtdRng
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqMaxExtdRngV
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqMinExtdRng
20251222_D5X-接收网段-2025-12-22.xlsx_EnToqMinExtdRngV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ECM_ZONE_050ms_Group09/ECM_ZONE_050ms_Group09</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ECM_ZONE_050ms_Group09</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECODrvngSpdRutA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EcoDrvngAIO</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EcoDrvngDspStsGearShftIndSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EcoDrvngDspStsRcmndFwdGear</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqMaxExtdRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqMaxExtdRngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqMinExtdRng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnToqMinExtdRngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_050ms_Group09_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_050ms_Group09_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_050ms_Group09_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_050ms_Group09_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ECM_ZONE_050ms_Group09_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_050ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8f7600">
                  <SHORT-NAME>EDUClntTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx
20250926_IS4GR-SIMU需求实施--分解实施表.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUClntTem/EDUClntTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EDUClntTem</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7afc00">
                  <SHORT-NAME>EDUClntTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250618_IP5PM EP EV高阶模型补充需求--袁萍补充勘误.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUClntTemV/EDUClntTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EDUClntTemV</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f3b412cac555f700">
                  <SHORT-NAME>EDUOilTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260707_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUOilTem/EDUOilTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EDUOilTem</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f3b412cac5581100">
                  <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260707_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUOilTemV/EDUOilTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EDUOilTemV</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb28c300">
                  <SHORT-NAME>ELKSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ELKSwReq/ELKSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ELKSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8af900">
                  <SHORT-NAME>EPSAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_MG6 PHEVEV 高配 有效性信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPSAvlbly/EPSAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPSAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb33e200">
                  <SHORT-NAME>EPSCTTX</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250207_export.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPSCTTX/EPSCTTX</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPSCTTX</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSCTTX</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb33bb00">
                  <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250207_export.xlsx_EPSAESReqResp
20250207_export.xlsx_EPSAESReqTorResp
20250207_export.xlsx_EPSAESReqTorRespV
20250207_export.xlsx_EPSAESStsInh
20250207_export.xlsx_EPS_010ms_Group03_CRC
20250207_export.xlsx_EPS_010ms_Group03_RC
20250207_export.xlsx_EPS_010ms_Group03_Reserved1
20250207_export.xlsx_EPS_010ms_Group03_Reserved2
20250207_export.xlsx_EPS_010ms_Group03_Reserved3
20250207_export.xlsx_EPS_010ms_Group03_Reserved4</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_010ms_Group03/EPS_010ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPS_010ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAESReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAESStsInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAESReqTorResp</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAESReqTorRespV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_010ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_010ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSVMCAngRespSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSVMCCodrivingSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSVMCRespStsInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_010ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_010ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_010ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_010ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb336d00">
                  <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250207_export.xlsx_ADASStrgDlvrdToq
20250207_export.xlsx_ADASStrgDlvrdToqV
20250207_export.xlsx_ActuPnonAng
20250207_export.xlsx_ActuPnonAngV
20250207_export.xlsx_ActuRoadWhlAng
20250207_export.xlsx_ActuRoadWhlAngV
20250207_export.xlsx_CHLKAHptResp
20250207_export.xlsx_ChLKAAngReqResp
20250207_export.xlsx_ChLKAToqReqResp
20250207_export.xlsx_DrvrStrgDlvrdToq
20250207_export.xlsx_DrvrStrgDlvrdToqV
20250207_export.xlsx_EPSCoDrivingSts
20250207_export.xlsx_EPSCurntDrvMd
20250207_export.xlsx_EPSDrvngMdCtrlInh
20250207_export.xlsx_EPSFlrSts
20250207_export.xlsx_EPSPriyChnlFlrSts
20250207_export.xlsx_EPSToqValAldMax
20250207_export.xlsx_EPSToqValAldMaxV
20250207_export.xlsx_EPSToqValAldMin
20250207_export.xlsx_EPSToqValAldMinV
20250207_export.xlsx_EPS_10ms_Group01_CRC
20250207_export.xlsx_EPS_10ms_Group01_RC
20250207_export.xlsx_EPS_10ms_Group01_Reserved1
20250207_export.xlsx_EPS_10ms_Group01_Reserved10
20250207_export.xlsx_EPS_10ms_Group01_Reserved11
20250207_export.xlsx_EPS_10ms_Group01_Reserved12
20250207_export.xlsx_EPS_10ms_Group01_Reserved13
20250207_export.xlsx_EPS_10ms_Group01_Reserved2
20250207_export.xlsx_EPS_10ms_Group01_Reserved3
20250207_export.xlsx_EPS_10ms_Group01_Reserved4
20250207_export.xlsx_EPS_10ms_Group01_Reserved5
20250207_export.xlsx_EPS_10ms_Group01_Reserved6
20250207_export.xlsx_EPS_10ms_Group01_Reserved7
20250207_export.xlsx_EPS_10ms_Group01_Reserved8
20250207_export.xlsx_EPS_10ms_Group01_Reserved9
20250207_export.xlsx_StrgCustSetngDspCmd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChLKAAngReqResp
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_CHLKAHptResp
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChLKAToqReqResp
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_DrvrStrgDlvrdToq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_DrvrStrgDlvrdToqV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_RC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved1
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved10
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved11
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved2
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved3
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved4
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved5
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved6
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPS_10ms_Group01_Reserved9
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSCoDrivingSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSCurntDrvMd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSDrvngMdCtrlInh
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSFlrSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSPriyChnlFlrSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSToqValAldMax
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSToqValAldMaxV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSToqValAldMin
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPSToqValAldMinV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_StrgCustSetngDspCmd
20250607_IP5PM EP信号需求V6.xlsx_ActuPnonAng
20250607_IP5PM EP信号需求V6.xlsx_ActuPnonAngV
20250607_IP5PM EP信号需求V6.xlsx_ActuRoadWhlAng
20250607_IP5PM EP信号需求V6.xlsx_ActuRoadWhlAngV
20250607_IP5PM EP信号需求V6.xlsx_ADASStrgDlvrdToq
20250607_IP5PM EP信号需求V6.xlsx_ADASStrgDlvrdToqV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrStrgDlvrdToq
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrStrgDlvrdToqV
20260706_modify.xlsx_ADASStrgDlvrdToq
20260706_modify.xlsx_ActuPnonAng
20260706_modify.xlsx_ActuRoadWhlAng
20260706_modify.xlsx_CHLKAHptResp
20260706_modify.xlsx_ChLKAAngReqResp
20260706_modify.xlsx_DrvrStrgDlvrdToq
20260706_modify.xlsx_EPSCurntDrvMd
20260706_modify.xlsx_EPSFlrSts
20260706_modify.xlsx_EPSToqValAldMax
20260706_modify.xlsx_EPSToqValAldMin</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group01/EPS_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPS_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuPnonAng</SHORT-LABEL>
                              <VALUE>0x8000</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuPnonAngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuRoadWhlAng</SHORT-LABEL>
                              <VALUE>0x7F58</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuRoadWhlAngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ADASStrgDlvrdToq</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ADASStrgDlvrdToqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChLKAAngReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CHLKAHptResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChLKAToqReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrStrgDlvrdToq</SHORT-LABEL>
                              <VALUE>0x800</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrStrgDlvrdToqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSCoDrivingSts</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSCurntDrvMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSDrvngMdCtrlInh</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSPriyChnlFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSToqValAldMax</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSToqValAldMaxV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSToqValAldMin</SHORT-LABEL>
                              <VALUE>0x400</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSToqValAldMinV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgCustSetngDspCmd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSActRetMotToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSActRetMotToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSLimMotToq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSLimMotToqV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved5</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved6</SHORT-LABEL>
                              <VALUE>0x1f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved8</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group01_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb339400">
                  <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250207_export.xlsx_ActuRoadWhlAngGrd
20250207_export.xlsx_ActuRoadWhlAngGrdV
20250207_export.xlsx_EPSAIPkgAngReqResp
20250207_export.xlsx_EPSAIPkgAngReqRespInh
20250207_export.xlsx_EPSAIPltAngRespSts
20250207_export.xlsx_EPSAIPltAngRespStsInh
20250207_export.xlsx_EPSAIPltAvlLvl
20250207_export.xlsx_EPSAIPltCtrlChannel
20250207_export.xlsx_EPS_10ms_Group02_CRC
20250207_export.xlsx_EPS_10ms_Group02_RC
20250207_export.xlsx_EPS_10ms_Group02_Reserved1
20250207_export.xlsx_EPS_10ms_Group02_Reserved2</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group02/EPS_10ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPS_10ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuRoadWhlAngGrd</SHORT-LABEL>
                              <VALUE>0x7F58</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ActuRoadWhlAngGrdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPkgAngReqRespInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPltAvlLvl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPltCtrlChannel</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPkgAngReqResp</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPltAngRespSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAIPltAngRespStsInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0x3f</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba03800">
                  <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251231_工作簿1-EV实施需求.xlsx_EPS_10ms_Group05_CRC
20251231_工作簿1-EV实施需求.xlsx_EPS_10ms_Group05_RC
20251231_工作簿1-EV实施需求.xlsx_EPS_10ms_Group05_Reserved1
20251231_工作簿1-EV实施需求.xlsx_EPS_10ms_Group05_Reserved2
20251231_工作簿1-EV实施需求.xlsx_EPS_10ms_Group05_Reserved3
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAng
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngGrd
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngSnsrCalSts
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngSnsrFlt
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngSnsrInid
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngSnsrMultCapb
20251231_工作簿1-EV实施需求.xlsx_StrgWhlAngV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAng
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngGrd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngSnsrCalSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngSnsrFlt
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngSnsrInid
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngSnsrMultCapb
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_StrgWhlAngV
20260706_modify.xlsx_StrgWhlAng</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_10ms_Group05/EPS_10ms_Group05</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPS_10ms_Group05</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAng</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngGrd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngSnsrCalSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngSnsrFlt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngSnsrInid</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngSnsrMultCapb</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>StrgWhlAngV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group05_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group05_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group05_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group05_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_10ms_Group05_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8aab00">
                  <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250624_加Group-梳理.xlsx_EPS_20ms_Group03_CRC
20250624_加Group-梳理.xlsx_EPS_20ms_Group03_RC
20250624_加Group-梳理.xlsx_EPSAPAInh
20250624_加Group-梳理.xlsx_EPSAPASts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPS_20ms_Group03/EPS_20ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPS_20ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAPAInh</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPSAPASts</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPS_20ms_Group03_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7b2300">
                  <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20260720_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPTClntPumpSta/EPTClntPumpSta</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPTClntPumpSta</SHORT-LABEL>
                          <VALUE>0xF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTClntPumpSta</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7b4a00">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250613_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPTElecWtrPumpActuSpd/EPTElecWtrPumpActuSpd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EPTElecWtrPumpActuSpd</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTElecWtrPumpActuSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7e2f00">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCBrkRgnPwrLmt_kW/ERCBrkRgnPwrLmt_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCBrkRgnPwrLmt_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCBrkRgnPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7e5600">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtPeak_kW/ERCChrgPwrLmtPeak_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCChrgPwrLmtPeak_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7e7d00">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtWhl_kW/ERCChrgPwrLmtWhl_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCChrgPwrLmtWhl_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ea400">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtPeak_kW/ERCDsChrgPwrLmtPeak_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCDsChrgPwrLmtPeak_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ecb00">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtWhl_kW/ERCDsChrgPwrLmtWhl_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCDsChrgPwrLmtWhl_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7ef200">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCEmgcyPwrDwn_flg/ERCEmgcyPwrDwn_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCEmgcyPwrDwn_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCEmgcyPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7f1900">
                  <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCFCOReq_flg/ERCFCOReq_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCFCOReq_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCFCOReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7f4000">
                  <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCHVAllwd_flg/ERCHVAllwd_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCHVAllwd_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVAllwd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7f6700">
                  <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCHVHldReq_flg/ERCHVHldReq_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCHVHldReq_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVHldReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7f8e00">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCMaxChrgPwrLmt_kW/ERCMaxChrgPwrLmt_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCMaxChrgPwrLmt_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxChrgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7fb500">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCMaxDschgPwrLmt_kW/ERCMaxDschgPwrLmt_kW</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ERCMaxDschgPwrLmt_kW</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxDschgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb911700">
                  <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251219_D5X EV 对比信号需求-2021219.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESCLPwrSts/ESCLPwrSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ESCLPwrSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESCLPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb679f00">
                  <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSAdoWrnngReq/ESSAdoWrnngReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ESSAdoWrnngReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8f0900">
                  <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_BMSOfbdChrgrSktVol
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_BMSOfbdChrgrSktVolV
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_BMSOffBdChrgrPlugOn
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_BMSOffBdChrgrPlugOnV
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_CRC
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_RC
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved1
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved2
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved3
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved4
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved5
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved6
20250828_20250827-D5X Simu EV CANLIN信号导出表阶段.xlsx_ESS_100ms_Group58_Reserved7
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_BMSOffBdChrgrPlugOn
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_BMSOffBdChrgrPlugOnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BMSOffBdChrgrPlugOn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BMSOffBdChrgrPlugOnV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESS_100ms_Group58/ESS_100ms_Group58</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ESS_100ms_Group58</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BMSOfbdChrgrSktVol</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BMSOfbdChrgrSktVolV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BMSOffBdChrgrPlugOn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BMSOffBdChrgrPlugOnV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved4</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved5</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ESS_100ms_Group58_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESS_100ms_Group58</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb677800">
                  <SHORT-NAME>ESSswReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSswReq/ESSswReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ESSswReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSswReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7fdc00">
                  <SHORT-NAME>EVMd_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EVMd_flg/EVMd_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EVMd_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EVMd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4a9e00">
                  <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EastVelocityRTK/EastVelocityRTK</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EastVelocityRTK</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EastVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb616100">
                  <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ElecPwrDistbnScene/ElecPwrDistbnScene</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ElecPwrDistbnScene</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ElecPwrDistbnScene</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb920100">
                  <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251210_D5X EV 对比信号需求.xlsx
20260720_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/En12VoltStrMotCmddOn/En12VoltStrMotCmddOn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>En12VoltStrMotCmddOn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/En12VoltStrMotCmddOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb800300">
                  <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngBrkTqMax_Nm/EngBrkTqMax_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngBrkTqMax_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngBrkTqMax_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb802a00">
                  <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFastTqReq_Nm/EngFastTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngFastTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb805100">
                  <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFastTqTypReq_enum/EngFastTqTypReq_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngFastTqTypReq_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqTypReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb807800">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFlexplateTqFstTgt_Nm/EngFlexplateTqFstTgt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngFlexplateTqFstTgt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqFstTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb809f00">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFlexplateTqSlowTgt_Nm/EngFlexplateTqSlowTgt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngFlexplateTqSlowTgt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqSlowTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb80c600">
                  <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngPhsAng_deg/EngPhsAng_deg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngPhsAng_deg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngPhsAng_deg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb80ed00">
                  <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngSlowTqReq_Nm/EngSlowTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngSlowTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSlowTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb811400">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngSpdSafe4EngStrt_flg/EngSpdSafe4EngStrt_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngSpdSafe4EngStrt_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSpdSafe4EngStrt_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb813b00">
                  <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStallCnt_cnt/EngStallCnt_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStallCnt_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStallCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb816200">
                  <SHORT-NAME>EngStall_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStall_cnt/EngStall_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStall_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStall_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb818900">
                  <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStopReqCfmd_flg/EngStopReqCfmd_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStopReqCfmd_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStopReqCfmd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb81b000">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtDampSlipFailCnt_cnt/EngStrtDampSlipFailCnt_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtDampSlipFailCnt_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtDampSlipFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb81d700">
                  <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtFailCnt_cnt/EngStrtFailCnt_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtFailCnt_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb81fe00">
                  <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtFail_cnt/EngStrtFail_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtFail_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFail_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb822500">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtNoCapFailCnt_cnt/EngStrtNoCapFailCnt_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtNoCapFailCnt_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtNoCapFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb824c00">
                  <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtReq_flg/EngStrtReq_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtReq_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb827300">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtStuckFailCnt_cnt/EngStrtStuckFailCnt_cnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>EngStrtStuckFailCnt_cnt</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtStuckFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9b7d00">
                  <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTBSysFltSts_ADAS/FCTBSysFltSts_ADAS</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTBSysFltSts_ADAS</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9ba400">
                  <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSwSts_ADAS/FCTSwSts_ADAS</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTSwSts_ADAS</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9bcb00">
                  <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251204_RZCU需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysFltSts_ADAS/FCTSysFltSts_ADAS</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTSysFltSts_ADAS</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb65cb00">
                  <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysSelReq/FCTSysSelReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCTSysSelReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb28ea00">
                  <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250207_ANB智驾L2+信号需求_20241127.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSnstvtLvlReq/FCWSnstvtLvlReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWSnstvtLvlReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb291100">
                  <SHORT-NAME>FCWSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250207_ANB智驾L2+信号需求_20241127.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSwReq/FCWSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FCWSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb48cb00">
                  <SHORT-NAME>FDRPwrSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250520_IP5PM EP信号需求--modify属性变更.xlsx
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FDRPwrSts/FDRPwrSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FDRPwrSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDRPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2c6b00">
                  <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250207_ANB智驾L2+信号需求_20241127.xlsx_FDRSts
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_CRC
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_RC
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved1
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved2
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved3
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved4
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved5
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved6
20250207_ANB智驾L2+信号需求_20241127.xlsx_FDR_100ms_Group01_Reserved7</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FDR_100ms_Group01/FDR_100ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FDR_100ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDRSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FDR_100ms_Group01_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDR_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2c1d00">
                  <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241128_副本总表_0.5_20241127.xlsx
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDircnLghtSts/FLDircnLghtSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLDircnLghtSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7a1a00">
                  <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250611_IP5PM EP信号需求V7-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDoorHndlPESwtActv/FLDoorHndlPESwtActv</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLDoorHndlPESwtActv</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb946900">
                  <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDoorOpenSts/FLDoorOpenSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLDoorOpenSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb96eb00">
                  <SHORT-NAME>FLTirePrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTirePrs/FLTirePrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLTirePrs</SHORT-LABEL>
                          <VALUE>0x37</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb971200">
                  <SHORT-NAME>FLTirePrsV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTirePrsV/FLTirePrsV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLTirePrsV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f498f2acb34f2400">
                  <SHORT-NAME>FLTireSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260710_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireSts/FLTireSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLTireSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb976000">
                  <SHORT-NAME>FLTireTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireTem/FLTireTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLTireTem</SHORT-LABEL>
                          <VALUE>0x2D</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb978700">
                  <SHORT-NAME>FLTireTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireTemV/FLTireTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLTireTemV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb913e00">
                  <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251219_D5X EV 对比信号需求-2021219.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLiDARPwrSts/FLiDARPwrSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FLiDARPwrSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLiDARPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb916500">
                  <SHORT-NAME>FOTAStatus</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTAStatus/FOTAStatus</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FOTAStatus</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb918c00">
                  <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTAStatusValid/FOTAStatusValid</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FOTAStatusValid</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatusValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb91b300">
                  <SHORT-NAME>FOTATarget</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTATarget/FOTATarget</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FOTATarget</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATarget</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb91da00">
                  <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251113_EP--AS5PR_EV高阶_20251107.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTATargetValid/FOTATargetValid</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FOTATargetValid</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATargetValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2c4400">
                  <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241128_副本总表_0.5_20241127.xlsx
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDircnLghtSts/FRDircnLghtSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRDircnLghtSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7a4100">
                  <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250611_IP5PM EP信号需求V7-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDoorHndlPESwtActv/FRDoorHndlPESwtActv</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRDoorHndlPESwtActv</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb949000">
                  <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDoorOpenSts/FRDoorOpenSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRDoorOpenSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb97ae00">
                  <SHORT-NAME>FRTirePrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTirePrs/FRTirePrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRTirePrs</SHORT-LABEL>
                          <VALUE>0x37</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb97d500">
                  <SHORT-NAME>FRTirePrsV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTirePrsV/FRTirePrsV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRTirePrsV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f498f2acb3534600">
                  <SHORT-NAME>FRTireSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260710_C1.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireSts/FRTireSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRTireSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb982300">
                  <SHORT-NAME>FRTireTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireTem/FRTireTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRTireTem</SHORT-LABEL>
                          <VALUE>0x2D</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb984a00">
                  <SHORT-NAME>FRTireTemV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireTemV/FRTireTemV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FRTireTemV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbada900">
                  <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCamrHeatSts/FrtCamrHeatSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtCamrHeatSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb63d000">
                  <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCarGoNotfrSwReq/FrtCarGoNotfrSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtCarGoNotfrSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb944200">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtPsngDoorOpenSts_LHZCU/FrtPsngDoorOpenSts_LHZCU</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtPsngDoorOpenSts_LHZCU</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPsngDoorOpenSts_LHZCU</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb987100">
                  <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtTireStdPrs/FrtTireStdPrs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtTireStdPrs</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbacea00">
                  <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSfcTem/FrtWindShldSfcTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtWindShldSfcTem</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSfcTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbad1100">
                  <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSurndHmdty/FrtWindShldSurndHmdty</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtWindShldSurndHmdty</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndHmdty</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbad3800">
                  <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSurndTem/FrtWindShldSurndTem</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtWindShldSurndTem</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb273d00">
                  <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241118_副本总表_0.3_20241118.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWiperSpd/FrtWiperSpd</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtWiperSpd</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb276400">
                  <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241118_副本总表_0.3_20241118.xlsx
20250523_IP5PM EP信号需求V2-热管理-输出--梳理1.xlsx
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWiperSwSts/FrtWiperSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FrtWiperSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb829a00">
                  <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FuCutReq_enum/FuCutReq_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FuCutReq_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FuCutReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb82c100">
                  <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutDMFPrdtn_flg/FulCutDMFPrdtn_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FulCutDMFPrdtn_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutDMFPrdtn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb82e800">
                  <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutEngStall_flg/FulCutEngStall_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FulCutEngStall_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutEngStall_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb830f00">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutLosCommWthEMS_flg/FulCutLosCommWthEMS_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>FulCutLosCommWthEMS_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutLosCommWthEMS_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4aec00">
                  <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/GNSSAntennasBroken/GNSSAntennasBroken</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>GNSSAntennasBroken</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4b1300">
                  <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/GNSSAntennasInfo/GNSSAntennasInfo</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>GNSSAntennasInfo</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb833600">
                  <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HCUSAMTqReq_Nm/HCUSAMTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HCUSAMTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HCUSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbad5f00">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HmdtySnsrHdwrFltPrst/HmdtySnsrHdwrFltPrst</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>HmdtySnsrHdwrFltPrst</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HmdtySnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb929500">
                  <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCOvTSuppresSwReq/IACCOvTSuppresSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IACCOvTSuppresSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb926e00">
                  <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreSpdLimtSwReq/IACCPreSpdLimtSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IACCPreSpdLimtSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8b2000">
                  <SHORT-NAME>IAMAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250625_MG6 PHEVEV 高配 有效性信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAMAvlbly/IAMAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAMAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb496600">
                  <SHORT-NAME>IAMReststs</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAMReststs/IAMReststs</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAMReststs</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMReststs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbafbf400">
                  <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_AltSigma
20260706_modify.xlsx_LatSigma
20260706_modify.xlsx_LonSigma</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group08/IAM_100ms_Group08</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_100ms_Group08</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AltSigma</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LatSigma</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LonSigma</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group08_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group08_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group08_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb197100">
                  <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_HeadingSigma
20260706_modify.xlsx_PitchRTK
20260706_modify.xlsx_PitchSigma</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group18/IAM_100ms_Group18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_100ms_Group18</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HeadingSigma</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PitchRTK</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>PitchSigma</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group18_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group18_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group18_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb1aec00">
                  <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_IAM_GNSS_Signal_Status
20260706_modify.xlsx_LatitudeRTK</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_100ms_Group56/IAM_100ms_Group56</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_100ms_Group56</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_GNSS_Signal_Status</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LatitudeRTK</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group56_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group56_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group56_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_100ms_Group56_Reserved13</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group56</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8fc000">
                  <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtDrvrTrgtEPSStrgWhlAng
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtParkngAstAbotBtnSts
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtParkngAstBtnSts
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtParkngAstDvcFlrRsn
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtParkngAstDvcSts
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_RmtParkngAstParkngOutDircnSeln
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehBkwdSwReq
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehBkwdSwReqV
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehFwdSwReq
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehFwdSwReqV
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehRoadWhlLReq
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehRoadWhlLReqV
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehRoadWhlRReq
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_VehRoadWhlRReqV
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_IAM_20ms_Group32_CRC
20250903_20250902-bl1-AS5PR&amp;AS5PM SignalGroup需求.xlsx_IAM_20ms_Group32_RC</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_20ms_Group32/IAM_20ms_Group32</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_20ms_Group32</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtDrvrTrgtEPSStrgWhlAng</SHORT-LABEL>
                              <VALUE>0x8000</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtParkngAstAbotBtnSts</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtParkngAstBtnSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtParkngAstDvcFlrRsn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtParkngAstDvcSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RmtParkngAstParkngOutDircnSeln</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehBkwdSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehBkwdSwReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehFwdSwReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehFwdSwReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehRoadWhlLReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehRoadWhlLReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehRoadWhlRReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehRoadWhlRReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved7</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved8</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved9</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_20ms_Group32_Reserved10</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_20ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb13b400">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_FixType
20260706_modify.xlsx_GNSSSeq
20260706_modify.xlsx_GNSSUTCTimeH</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group13/IAM_ZONE_100ms_Group13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_ZONE_100ms_Group13</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>FixType</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>GNSSSeq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>GNSSUTCTimeH</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group13_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group13_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group13_Reserved13</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb17a100">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_Hdop
20260706_modify.xlsx_Pdop
20260706_modify.xlsx_Vdop</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group34/IAM_ZONE_100ms_Group34</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_ZONE_100ms_Group34</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Hdop</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Pdop</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>Vdop</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_Reserved23</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_Reserved39</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_Reserved55</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group34_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group34</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb152f00">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_GNSSF9HCounter
20260706_modify.xlsx_GNSSUTCTime</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group35/IAM_ZONE_100ms_Group35</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_ZONE_100ms_Group35</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>GNSSF9HCounter</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>GNSSUTCTime</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group35_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group35_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group35_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group35</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbafd6f00">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_AltitudeRTK
20260706_modify.xlsx_HeadingRTK</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group40/IAM_ZONE_100ms_Group40</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_ZONE_100ms_Group40</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AltitudeRTK</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HeadingRTK</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group40_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group40_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group40_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group40_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group40</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdbb1f6600">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx_LongitudeRTK</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group57/IAM_ZONE_100ms_Group57</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IAM_ZONE_100ms_Group57</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LongitudeRTK</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group57_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group57_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group57_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IAM_ZONE_100ms_Group57_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group57</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb883100">
                  <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_CsbLvlSts
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_DistRCAvgDrvn
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_DistRCAvgDrvnRstOcd
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_DistRCAvgDrvnSrc
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_DistRCAvgDrvnV
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_CRC
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_RC
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved1
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved2
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved3
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved4
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved5
20250616_IP5PM EP信号需求-EV高阶-输出.xlsx_IBS_100ms_Group15_Reserved6
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBSABSlvlResp
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBSESPlvlResp
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBSTCSlvlResp
20260703_modify.xlsx_IBSESPlvlResp
20260703_modify.xlsx_IBSTCSlvlResp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_100ms_Group15/IBS_100ms_Group15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_100ms_Group15</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DistRCAvgDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DistRCAvgDrvnRstOcd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DistRCAvgDrvnSrc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DistRCAvgDrvnV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CsbLvlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkFltAlrm_GB</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkFrc_GB</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBSABSlvlResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBSESPlvlResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBSTCSlvlResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved3</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved4</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_100ms_Group15_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_100ms_Group15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb907f00">
                  <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlDistPlsCtr
20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlDistTRC
20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlDistTmsp
20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlDistV
20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlRstOcd
20250930_20250930-发版前路由更改需求.xlsx_LDrvnWhlRotlSeqNum
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlDistPlsCtr
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlDistTRC
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlDistTmsp
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlDistV
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlRstOcd
20250930_20250930-发版前路由更改需求.xlsx_RDrvnWhlRotlSeqNum
20251114_EP--AS5PR_EV高阶_20251107.xlsx_LDrvnWhlRotlDistPlsCtr
20251114_EP--AS5PR_EV高阶_20251107.xlsx_LDrvnWhlRotlDistV
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RDrvnWhlRotlDistPlsCtr
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlDistPlsCtr
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlDistTRC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlDistTmsp
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlRstOcd
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LDrvnWhlRotlSeqNum
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlDistPlsCtr
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlDistTRC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlDistTmsp
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlRstOcd
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RDrvnWhlRotlSeqNum
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlDistPlsCtr
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlDistTRC
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlDistTmsp
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlDistV
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlRstOcd
20251219_D5X EV 对比信号需求-2021219.xlsx_LDrvnWhlRotlSeqNum
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlDistPlsCtr
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlDistTRC
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlDistTmsp
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlDistV
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlRstOcd
20251219_D5X EV 对比信号需求-2021219.xlsx_RDrvnWhlRotlSeqNum
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_LDrvnWhlRotlDistPlsCtr
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RDrvnWhlRotlDistPlsCtr</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group01/IBS_10ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_10ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDistPlsCtr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDistTmsp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDistTRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDistV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlRstOcd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlSeqNum</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDistPlsCtr</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDistTmsp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDistTRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDistV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlRstOcd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlSeqNum</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb90a600">
                  <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlDistPC
20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlDistT
20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlDistTRC
20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlDistV
20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlRstOcd
20250930_20250930-发版前路由更改需求.xlsx_LNonDrvnWhlRotlSeqNum
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlDistPC
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlDistT
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlDistTRC
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlDistV
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlRstOcd
20250930_20250930-发版前路由更改需求.xlsx_RNonDrvnWhlRotlSeqNum
20251114_EP--AS5PR_EV高阶_20251107.xlsx_LNonDrvnWhlRotlDistPC
20251114_EP--AS5PR_EV高阶_20251107.xlsx_LNonDrvnWhlRotlDistV
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RNonDrvnWhlRotlDistPC
20251114_EP--AS5PR_EV高阶_20251107.xlsx_RNonDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlDistPC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlDistT
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlDistTRC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlRstOcd
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_LNonDrvnWhlRotlSeqNum
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlDistPC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlDistT
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlDistTRC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlDistV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlRstOcd
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_RNonDrvnWhlRotlSeqNum
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlDistPC
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlDistT
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlDistTRC
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlDistV
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlRstOcd
20251219_D5X EV 对比信号需求-2021219.xlsx_LNonDrvnWhlRotlSeqNum
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlDistPC
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlDistT
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlDistTRC
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlDistV
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlRstOcd
20251219_D5X EV 对比信号需求-2021219.xlsx_RNonDrvnWhlRotlSeqNum
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_LNonDrvnWhlRotlDistPC
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RNonDrvnWhlRotlDistPC</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group02/IBS_10ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_10ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDistPC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDistT</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDistTRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDistV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlRstOcd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlSeqNum</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDistPC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDistT</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDistTRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDistV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlRstOcd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlSeqNum</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb47bd00">
                  <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlPos
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlPosV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkSysBrkLghtsReqd
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved1
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved2
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved3
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved4
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved5
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_10ms_Group04_Reserved6
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlPos
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlPosV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkSysBrkLghtsReqd
20260528_新增接收.xlsx_BrkPdlPos
20260528_新增接收.xlsx_BrkPdlPosV
20260601_修改1.xlsx_BrkPdlPos
20260601_修改1.xlsx_BrkPdlPosV
20260706_modify.xlsx_BrkPdlPos
20260706_modify.xlsx_BrkPdlPosV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_10ms_Group04/IBS_10ms_Group04</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_10ms_Group04</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlPosV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysBrkLghtsReqd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysEnToqReqProtn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSysBrkLghtsReqdA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved3</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved4</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved5</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_10ms_Group04_Reserved6</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb47e300">
                  <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_ABSA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_ABSF
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_ABSIO
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_AutoHoldMdSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_AutoHoldMsg
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_AutoHoldSysSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_AVHSigPdlSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkSysHillStAstAvlbl
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkSysHillStAstSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkSysRedBrkTlltReq
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkSysYlwBrkTlltReq
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_EBDA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_EBDFaultSt
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_EmgcBrkA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_EmgcBrkAV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_EnDragToqRducnA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_HBAActiveSt
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_HBAValidSt
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_HDCSysSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group07_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group07_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_MSRA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_MSRF
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_MulColBrkA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_MulColBrkAvlblySts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_MultColBrkEnbA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RgtvBrkFnFltSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RgtvBrkFnSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SoftSpSysSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_TCSA
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_TCSEnbd
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_TCSOpngMd
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_TCSOpngSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSEMd
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSESts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSESysA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkSysHillStAstAvlbl
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkSysHillStAstSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkSysRedBrkTlltReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkSysYlwBrkTlltReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EBDA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EBDFaultSt
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EmgcBrkA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EmgcBrkAV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EnDragToqRducnA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_HBAActiveSt
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_HBAValidSt
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_HDCSysSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group07_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group07_RC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_MSRA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_MSRF
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_MulColBrkA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_MulColBrkAvlblySts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_MultColBrkEnbA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RgtvBrkFnFltSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RgtvBrkFnSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_SoftSpSysSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_TCSA
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_TCSEnbd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_TCSOpngMd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_TCSOpngSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_VSEMd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_VSESts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_VSESysA
20250607_IP5PM EP信号需求V6.xlsx_ABSA
20250607_IP5PM EP信号需求V6.xlsx_ABSF
20250607_IP5PM EP信号需求V6.xlsx_ABSIO
20250607_IP5PM EP信号需求V6.xlsx_AutoHoldMdSts
20250607_IP5PM EP信号需求V6.xlsx_AutoHoldMsg
20250607_IP5PM EP信号需求V6.xlsx_AutoHoldSysSts
20250607_IP5PM EP信号需求V6.xlsx_AVHSigPdlSts
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_ABSA
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_TCSA
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VSESysA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ABSA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ABSF
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_AutoHoldMdSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TCSA
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TCSOpngMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TCSOpngSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSEMd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSESts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSESysA</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group07/IBS_20ms_Group07</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group07</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AVHSigPdlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group07_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group07_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ABSA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ABSF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ABSIO</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoHoldMdSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoHoldMsg</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutoHoldSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysHillStAstAvlbl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysHillStAstSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysRedBrkTlltReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysYlwBrkTlltReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EBDA</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EBDFaultSt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EmgcBrkA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EmgcBrkAV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EnDragToqRducnA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HBAActiveSt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HBAValidSt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>HDCSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MSRA</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MSRF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MulColBrkA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MulColBrkAvlblySts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MultColBrkEnbA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RgtvBrkFnFltSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RgtvBrkFnSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SoftSpSysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCSA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCSEnbd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCSOpngMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCSOpngSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSEMd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSESts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSESysA</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb611700">
                  <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysSecyBrkAxleToqVal
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysSecyBrkAxleToqValV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysTrBrkAxleToqVal
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysTrBrkAxleToqValV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBAPAAvlbl
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBAppcnSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBAvlblySts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBCCCanclReqd
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBFlrSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSwSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSwStsV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSysAudWrnngReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSysDspMsgReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSysStsIndReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_EPBSysWrnngIndReq
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group08_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group08_RC
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_EPBAppcnSts
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_EPBAppcnSts
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_EPBSts
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_EPBAppcnSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPBAppcnSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_EPBAvlblySts
20260706_modify.xlsx_EPBAppcnSts
20260706_modify.xlsx_EPBSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group08/IBS_20ms_Group08</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group08</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysSecyBrkAxleToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysSecyBrkAxleToqValV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysTrBrkAxleToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysTrBrkAxleToqValV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group08_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group08_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBAPAAvlbl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBAppcnSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBAvlblySts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBCCCanclReqd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBFlrSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSwSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSwStsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSysAudWrnngReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSysDspMsgReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSysStsIndReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EPBSysWrnngIndReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb480a00">
                  <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_ChSysTotBrkAxleToqVal
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_ChSysTotBrkAxleToqValV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group09_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group09_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group09_Reserved1
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_LDrvnWhlRotlDircn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_LDrvnWhlRotlDircnSdslSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RDrvnWhlRotlDircn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RDrvnWhlRotlDircnSdslSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelLDrvn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelLDrvnV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelRDrvn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelRDrvnV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysTotBrkAxleToqVal
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_ChSysTotBrkAxleToqValV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group09_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group09_RC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group09_Reserved1
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_LDrvnWhlRotlDircn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_LDrvnWhlRotlDircnSdslSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RDrvnWhlRotlDircn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RDrvnWhlRotlDircnSdslSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelLDrvn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelLDrvnV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelRDrvn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelRDrvnV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelLDrvn
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelLDrvnV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelRDrvn
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelRDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ChSysTotBrkAxleToqVal
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_ChSysTotBrkAxleToqValV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_LDrvnWhlRotlDircn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RDrvnWhlRotlDircn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelLDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelLDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelRDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelRDrvnV
20260528_新增接收.xlsx_LDrvnWhlRotlDircn
20260528_新增接收.xlsx_RDrvnWhlRotlDircn
20260601_修改1.xlsx_LDrvnWhlRotlDircn
20260601_修改1.xlsx_RDrvnWhlRotlDircn</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group09/IBS_20ms_Group09</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group09</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group09_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group09_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysTotBrkAxleToqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>ChSysTotBrkAxleToqValV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDircn</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDrvnWhlRotlDircnSdslSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDircn</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDrvnWhlRotlDircnSdslSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelLDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelLDrvnV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelRDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelRDrvnV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group09_Reserved1</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb483000">
                  <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkDiscTemSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkFludLvlLow
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkFludLvlLowV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlAppd
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlAppdV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlDrvrAppdPrs
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlDrvrAppdPrsDet
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlDrvrAppdPrsDetV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlDrvrAppdPrsV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlMdlActSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlMdlSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlSimltdPrs
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_BrkPdlSimltdPrsV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_DrvrReqOtptRodTrvl
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_DrvrReqOtptRodTrvlSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group10_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group10_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group10_Reserved1
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group10_Reserved2
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkPdlMdlActSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkPdlMdlSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkPdlSimltdPrs
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_BrkPdlSimltdPrsV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_DrvrReqOtptRodTrvl
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_DrvrReqOtptRodTrvlSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group10_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group10_RC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group10_Reserved1
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group10_Reserved2
20250607_IP5PM EP信号需求V6.xlsx_BrkDiscTemSts
20250607_IP5PM EP信号需求V6.xlsx_BrkFludLvlLow
20250607_IP5PM EP信号需求V6.xlsx_BrkFludLvlLowV
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlAppd
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlAppdV
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlDrvrAppdPrs
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlDrvrAppdPrsDet
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlDrvrAppdPrsDetV
20250607_IP5PM EP信号需求V6.xlsx_BrkPdlDrvrAppdPrsV
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_BrkFludLvlLow
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_BrkFludLvlLowV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_BrkPdlDrvrAppdPrs
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_BrkPdlDrvrAppdPrsV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkDiscTemSts
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkFludLvlLow
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkFludLvlLowV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlAppd
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlAppdV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlDrvrAppdPrs
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlDrvrAppdPrsDet
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlDrvrAppdPrsDetV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlDrvrAppdPrsV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlSimltdPrs
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_BrkPdlSimltdPrsV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrReqOtptRodTrvl
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_DrvrReqOtptRodTrvlSts
20260706_modify.xlsx_BrkPdlAppd
20260706_modify.xlsx_DrvrReqOtptRodTrvl
20260706_modify.xlsx_DrvrReqOtptRodTrvlSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group10/IBS_20ms_Group10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group10</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkDiscTemSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkFludLvlLow</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkFludLvlLowV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlAppd</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlAppdV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlDrvrAppdPrs</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlDrvrAppdPrsDet</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlDrvrAppdPrsDetV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlDrvrAppdPrsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlMdlActSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlMdlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlSimltdPrs</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkPdlSimltdPrsV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqOtptRodTrvl</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrReqOtptRodTrvlSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group10_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group10_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group10_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group10_Reserved2</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb8d4100">
                  <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250627_PHEV改错.xlsx_IBS_20ms_Group11_CRC
20250627_PHEV改错.xlsx_IBS_20ms_Group11_RC
20250627_PHEV改错.xlsx_IBS_20ms_Group11_Reserved1
20250627_PHEV改错.xlsx_VehSpdAvg
20250627_PHEV改错.xlsx_VehSpdAvgDrvn
20250627_PHEV改错.xlsx_VehSpdAvgDrvnSrc
20250627_PHEV改错.xlsx_VehSpdAvgDrvnV
20250627_PHEV改错.xlsx_VehSpdAvgNonDrvn
20250627_PHEV改错.xlsx_VehSpdAvgNonDrvnV
20250627_PHEV改错.xlsx_VehSpdAvgV
20250714_工作簿3-20250710.xlsx_IBS_20ms_Group11_CRC
20250714_工作簿3-20250710.xlsx_IBS_20ms_Group11_RC
20250714_工作簿3-20250710.xlsx_IBS_20ms_Group11_Reserved1
20250714_工作簿3-20250710.xlsx_VehSpdAvg
20250714_工作簿3-20250710.xlsx_VehSpdAvgDrvn
20250714_工作簿3-20250710.xlsx_VehSpdAvgDrvnSrc
20250714_工作簿3-20250710.xlsx_VehSpdAvgDrvnV
20250714_工作簿3-20250710.xlsx_VehSpdAvgNonDrvn
20250714_工作簿3-20250710.xlsx_VehSpdAvgNonDrvnV
20250714_工作簿3-20250710.xlsx_VehSpdAvgV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvg
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgDrvnSrc
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgNonDrvn
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgNonDrvnV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgV
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgDrvn
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VehSpdAvgDrvnV
20251114_EP--AS5PR_EV高阶_20251107.xlsx_IBS_20ms_Group11_CRC
20251114_EP--AS5PR_EV高阶_20251107.xlsx_IBS_20ms_Group11_RC
20251114_EP--AS5PR_EV高阶_20251107.xlsx_IBS_20ms_Group11_Reserved1
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvg
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgDrvn
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgDrvnSrc
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgDrvnV
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgNonDrvn
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgNonDrvnV
20251114_EP--AS5PR_EV高阶_20251107.xlsx_VehSpdAvgV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_IBS_20ms_Group11_CRC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_IBS_20ms_Group11_RC
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_IBS_20ms_Group11_Reserved1
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvg
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgDrvn
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgDrvnSrc
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgDrvnV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgNonDrvn
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgNonDrvnV
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx_VehSpdAvgV
20251222_D5X-接收网段-2025-12-22.xlsx_IBS_20ms_Group11_CRC
20251222_D5X-接收网段-2025-12-22.xlsx_IBS_20ms_Group11_RC
20251222_D5X-接收网段-2025-12-22.xlsx_IBS_20ms_Group11_Reserved1
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvg
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgDrvn
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgDrvnSrc
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgDrvnV
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgNonDrvn
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgNonDrvnV
20251222_D5X-接收网段-2025-12-22.xlsx_VehSpdAvgV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_IBS_20ms_Group11_CRC
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_IBS_20ms_Group11_RC
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvg
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgDrvn
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgDrvnSrc
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgDrvnV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgNonDrvn
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgNonDrvnV
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx_VehSpdAvgV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBS_20ms_Group11_CRC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBS_20ms_Group11_RC
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvg
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvn
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvnSrc
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvnV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgNonDrvn
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgNonDrvnV
20260212_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBS_20ms_Group11_CRC
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_IBS_20ms_Group11_RC
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvg
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvnSrc
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgNonDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgNonDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehSpdAvgV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_IBS_20ms_Group11_CRC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_IBS_20ms_Group11_RC
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvg
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgDrvn
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgDrvnSrc
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgDrvnV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgNonDrvn
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgNonDrvnV
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx_VehSpdAvgV
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehSpdAvg
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VehSpdAvgV
20260703_modify.xlsx_VehSpdAvgDrvn
20260703_modify.xlsx_VehSpdAvgNonDrvn
20260703_modify.xlsx_VehSpdAvgDrvnV
20260703_modify.xlsx_VehSpdAvgNonDrvnV
20260706_modify.xlsx_VehSpdAvg</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group11/IBS_20ms_Group11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group11</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group11_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group11_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvg</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgDrvnSrc</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgDrvnV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgNonDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgNonDrvnV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSpdAvgV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group11_Reserved1</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb485700">
                  <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group12_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group12_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group12_Reserved1
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_IBS_20ms_Group12_Reserved2
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_LNonDrvnWhlRotlDircn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_LNonDrvnWhlRotlDircnSdslSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RNonDrvnWhlRotlDircn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_RNonDrvnWhlRotlDircnSdslSts
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelLNonDrvn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelLNonDrvnV
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelRNonDrvn
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_WhlGndVelRNonDrvnV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group12_CRC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group12_RC
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group12_Reserved1
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_IBS_20ms_Group12_Reserved2
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_LNonDrvnWhlRotlDircn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_LNonDrvnWhlRotlDircnSdslSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RNonDrvnWhlRotlDircn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_RNonDrvnWhlRotlDircnSdslSts
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelLNonDrvn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelLNonDrvnV
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelRNonDrvn
20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx_WhlGndVelRNonDrvnV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelLNonDrvn
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelLNonDrvnV
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelRNonDrvn
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_WhlGndVelRNonDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_LNonDrvnWhlRotlDircn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_RNonDrvnWhlRotlDircn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelLNonDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelLNonDrvnV
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelRNonDrvn
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_WhlGndVelRNonDrvnV
20260528_新增接收.xlsx_RNonDrvnWhlRotlDircn
20260528_新增接收.xlsx_LNonDrvnWhlRotlDircn
20260601_修改1.xlsx_LNonDrvnWhlRotlDircn
20260601_修改1.xlsx_RNonDrvnWhlRotlDircn</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group12/IBS_20ms_Group12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group12</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group12_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group12_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDircnSdslSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDircn</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RNonDrvnWhlRotlDircnSdslSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelLNonDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelLNonDrvnV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelRNonDrvn</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>WhlGndVelRNonDrvnV</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LNonDrvnWhlRotlDircn</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group12_Reserved1</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>IBS_20ms_Group12_Reserved2</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f8755c01b1f9af00">
                  <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260722_C1.xlsx_ACCBrkngA
20260722_C1.xlsx_AutodDrvngSysMdReqResp
20260722_C1.xlsx_AutodDrvngSysMdReqRespV
20260722_C1.xlsx_BrkSysRddySysSts
20260722_C1.xlsx_ChACCAccReqResp
20260722_C1.xlsx_ChACCReqFlrSts
20260722_C1.xlsx_ChAEBBrkJerkReqResp
20260722_C1.xlsx_ChAEBDclReqResp
20260722_C1.xlsx_ChAEBHydBrkAstReqResp
20260722_C1.xlsx_ChAEBPrflReqResp
20260722_C1.xlsx_ChEBADclReqResp
20260722_C1.xlsx_ChRCTBDclReqResp
20260722_C1.xlsx_ChRCTBPrflReqResp
20260722_C1.xlsx_EmgcBrkReqdByIECUSts
20260722_C1.xlsx_ExtnlBrkPrio
20260722_C1.xlsx_ExtnlBrkPrioV
20260722_C1.xlsx_IBSAPASysFltSts
20260722_C1.xlsx_IBS_20ms_Group13_CRC
20260722_C1.xlsx_IBS_20ms_Group13_RC
20260722_C1.xlsx_MultColBrkAvlblySts
20260722_C1.xlsx_SCSAPAAcclA
20260722_C1.xlsx_SCSAPAAcclAV
20260722_C1.xlsx_SCSAutodDrvngSysSts
20260722_C1.xlsx_SCSAutodDrvngSysStsV
20260722_C1.xlsx_SCSVehHoldA
20260722_C1.xlsx_SCSVehHoldAV
20260722_C1.xlsx_TCSDrvrItnt
20260722_C1.xlsx_VehSdslSts
20260722_C1.xlsx_VehSdslStsV
20260722_C1.xlsx_WhlBrkPrsSts</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_20ms_Group13/IBS_20ms_Group13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>IBS_20ms_Group13</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkSysRddySysSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>EmgcBrkReqdByIECUSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>MultColBrkAvlblySts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCSDrvrItnt</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
