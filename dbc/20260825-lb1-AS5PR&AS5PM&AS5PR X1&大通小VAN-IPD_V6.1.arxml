发送方描述:AGS1动作状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSMoveStatus1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSMoveStatus1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSMoveStatus1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a1a3XOa505a3f19f25843c4b31a1a200">
              <SHORT-NAME>IAGSMoveStatus2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Move Status 2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS2动作状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSMoveStatus2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSMoveStatus2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSMoveStatus2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a27cXOa505a3f19f25843c4b31a27b00">
              <SHORT-NAME>IAGSSelflearnStatus1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Self-learn Status 1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS1自学习状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSSelflearnStatus1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSSelflearnStatus1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSSelflearnStatus1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a2d9XOa505a3f19f25843c4b31a2d800">
              <SHORT-NAME>IAGSSelflearnStatus2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Self-learn Status 2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS2自学习状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSSelflearnStatus2</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSSelflearnStatus2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSSelflearnStatus2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a25dXOa505a3f19f25843c4b31a25c00">
              <SHORT-NAME>IAGSTorqueResponse1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Torque Response 1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS1增扭反馈
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSTorqueResponse1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSTorqueResponse1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSTorqueResponse1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a317XOa505a3f19f25843c4b31a31600">
              <SHORT-NAME>IAGSTorqueResponse2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Torque Response 2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS2增扭反馈
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSTorqueResponse2</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSTorqueResponse2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSTorqueResponse2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f1f1XOa505a3f19f25843c4b34f1f000">
              <SHORT-NAME>IAIBOTPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AIBOT Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZXD播报负载配电通断状态
接收方描述:LHZCU,RHZCU,RZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:配电</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIBOTPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIBOTPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIBOTPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323f36XOa505a3f19f25843c4b323f3500">
              <SHORT-NAME>IAIParkngDsp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking Display</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:APA/RPA
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngDsp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngDsp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34657cXOa505a3f19f25843c4b34657b00">
              <SHORT-NAME>IAIParkngEPAMdsts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AIParking Exterior Parking Assist Model Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngEPAMdsts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngEPAMdsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngEPAMdsts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3496f5XOa505a3f19f25843c4b3496f400">
              <SHORT-NAME>IAIParkngEPAMdsw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AIParking Exterior Parking Assist Model Switch</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngEPAMdsw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngEPAMdsw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngEPAMdsw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31aa63XOa505a3f19f25843c4b31aa6200">
              <SHORT-NAME>IAIParkngReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ParkingRequest</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372161XOa505a3f19f25843c4b37216000">
              <SHORT-NAME>IAIParkngReqICB</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AIParking Function Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:IPA AVP MMT的HMI需求表给的是AIParkngReqICB，RPA是AIParkngReq_ZXD
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):0.0
Num. Of Repetition:0.0
Signal Type:ENM
备注:高阶智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngReqICB</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngReqICB</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReqICB</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31b19eXOa505a3f19f25843c4b31b19d00">
              <SHORT-NAME>IAIParkngReq_ZXD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ParkingRequest_ZXD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:泊车请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngReq_ZXD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngReq_ZXD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReq_ZXD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3461e4XOa505a3f19f25843c4b3461e300">
              <SHORT-NAME>IAIParkngRespICB</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AIParking Function Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):20.0
Num. Of Repetition:0.0
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngRespICB</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngRespICB</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngRespICB</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ab5fXOa505a3f19f25843c4b37ab5e00">
              <SHORT-NAME>IAIParkngSSPLotSw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking Silent Search Parking Slot Switch Set</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngSSPLotSw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngSSPLotSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSSPLotSw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379f82XOa505a3f19f25843c4b379f8100">
              <SHORT-NAME>IAIParkngSSPLotSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking Silent Search Parking Slot Switch Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngSSPLotSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngSSPLotSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSSPLotSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32318eXOa505a3f19f25843c4b32318d00">
              <SHORT-NAME>IAIParkngSpcID</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AI_Parking_Space_ID</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:车位选择ID
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngSpcID</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngSpcID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSpcID</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323302XOa505a3f19f25843c4b32330100">
              <SHORT-NAME>IAIParkngSpdsw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking speed switch</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngSpdsw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngSpdsw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSpdsw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3244e7XOa505a3f19f25843c4b3244e600">
              <SHORT-NAME>IAIParkngSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ZXD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIParkngSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIParkngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323a7cXOa505a3f19f25843c4b323a7b00">
              <SHORT-NAME>IAIPilotIntervQuit</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Pilot Intervene Quit</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:智驾退出原因
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIPilotIntervQuit</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIPilotIntervQuit</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotIntervQuit</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaeb5XOa505a3f19f25843c4b2eaeb400">
              <SHORT-NAME>IAIPilotSysSaBrInh</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Pilot Control System High Level Safety Braking Fault Inhibit Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:IMCU VMC
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIPilotSysSaBrInh</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIPilotSysSaBrInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotSysSaBrInh</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaed4XOa505a3f19f25843c4b2eaed300">
              <SHORT-NAME>IAIPilotSysSaBrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Pilot Control System High Level Safety Braking Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:IMCU VMC
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIPilotSysSaBrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIPilotSysSaBrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotSysSaBrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b0fcXOa505a3f19f25843c4b34b0fb00">
              <SHORT-NAME>IAIPkgAPASCSAcclReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ai Parking APA Acceleration Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:IPD与RWS握手及交互信号
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AIPkgAPASCSAcclReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>11</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AIPkgAPASCSAcclReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPkgAPASCSAcclReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f077XOa505a3f19f25843c4b34f07600">
              <SHORT-NAME>IAISocMngtActv</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AI SOC Management Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:AI能量管理
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AISocMngtActv</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AISocMngtActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AISocMngtActv</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b38bXOa505a3f19f25843c4b34b38a00">
              <SHORT-NAME>IALCSysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ALC System Failure Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:
有无服务标签:null
发送方描述:ALC故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ALCSysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ALCSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b3a6XOa505a3f19f25843c4b34b3a500">
              <SHORT-NAME>IALCSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Lane_Change_System_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:Y,有无服务标签:
有无服务标签:
发送方描述:ALC系统状态
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ALCSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ALCSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ALCSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369430XOa505a3f19f25843c4b36942f00">
              <SHORT-NAME>IAMRPrtensonReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AMR_Pretension_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:AMR请求状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AMRPrtensonReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AMRPrtensonReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AMRPrtensonReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3692b2XOa505a3f19f25843c4b3692b100">
              <SHORT-NAME>IAPACmdEPSSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Command Electric Power Steering Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:APA握手状态
接收方描述:EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APACmdEPSSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APACmdEPSSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACmdEPSSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323798XOa505a3f19f25843c4b32379700">
              <SHORT-NAME>IAPACrpSpdReqVal_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Creep Speed Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APACrpSpdReqVal_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APACrpSpdReqVal_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APACrpSpdReqVal_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b117XOa505a3f19f25843c4b34b11600">
              <SHORT-NAME>IAPAEPBOPReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Electric Park Brake Operation Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAEPBOPReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAEPBOPReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b132XOa505a3f19f25843c4b34b13100">
              <SHORT-NAME>IAPAEPBOPReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Electric Park Brake Operation Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAEPBOPReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAEPBOPReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEPBOPReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b2d2XOa505a3f19f25843c4b34b2d100">
              <SHORT-NAME>IAPAEnRunReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Engine Run Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group49
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAEnRunReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAEnRunReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnRunReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d07XOa505a3f19f25843c4b376d0600">
              <SHORT-NAME>IAPAEnToqReqSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAEnToqReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAEnToqReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d1eXOa505a3f19f25843c4b376d1d00">
              <SHORT-NAME>IAPAEnToqReqVal</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAEnToqReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAEnToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAEnToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3692d1XOa505a3f19f25843c4b3692d000">
              <SHORT-NAME>IAPAF</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Failed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:APA节点状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAF</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAF</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3232c4XOa505a3f19f25843c4b3232c300">
              <SHORT-NAME>IAPAOneKeyParkSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">APA_One_Key_Parking_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:随停即走按钮请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAOneKeyParkSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAOneKeyParkSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAOneKeyParkSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3240aaXOa505a3f19f25843c4b3240a900">
              <SHORT-NAME>IAPAParkInOffsetType</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">apa_park_in_offset_type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAParkInOffsetType</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAParkInOffsetType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAParkInOffsetType</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323248XOa505a3f19f25843c4b32324700">
              <SHORT-NAME>IAPAParkInOffsetTypeReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">apa_change_park_in_offset_type_request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAParkInOffsetTypeReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAParkInOffsetTypeReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAParkInOffsetTypeReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32404dXOa505a3f19f25843c4b32404c00">
              <SHORT-NAME>IAPARemShifGear</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">apa_remaining_shift_gear</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APARemShifGear</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APARemShifGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APARemShifGear</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369044XOa505a3f19f25843c4b36904300">
              <SHORT-NAME>IAPARevrDrgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Reverse Drag Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APARevrDrgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APARevrDrgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APARevrDrgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b14dXOa505a3f19f25843c4b34b14c00">
              <SHORT-NAME>IAPASCSAcclReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Stability Control System Acceleration Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSAcclReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSAcclReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSAcclReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d35XOa505a3f19f25843c4b376d3400">
              <SHORT-NAME>IAPASCSBrkFn</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSBrkFn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSBrkFn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d4cXOa505a3f19f25843c4b376d4b00">
              <SHORT-NAME>IAPASCSBrkFnMd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSBrkFnMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSBrkFnMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSBrkFnMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d63XOa505a3f19f25843c4b376d6200">
              <SHORT-NAME>IAPASCSDrvrReqSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSDrvrReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSDrvrReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSDrvrReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d7aXOa505a3f19f25843c4b376d7900">
              <SHORT-NAME>IAPASCSParkngPrflReq</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSParkngPrflReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSParkngPrflReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngPrflReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376d91XOa505a3f19f25843c4b376d9000">
              <SHORT-NAME>IAPASCSParkngTrgtDist</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSParkngTrgtDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSParkngTrgtDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngTrgtDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376da8XOa505a3f19f25843c4b376da700">
              <SHORT-NAME>IAPASCSParkngVelMax</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSParkngVelMax</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSParkngVelMax</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSParkngVelMax</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376dbfXOa505a3f19f25843c4b376dbe00">
              <SHORT-NAME>IAPASCSReqSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IPD_20ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b3c1XOa505a3f19f25843c4b34b3c000">
              <SHORT-NAME>IAPASCSToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advance Park Assist Stability Control System Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:
有无服务标签:null
发送方描述:泊车条线新增IBS扭矩值请求值
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCSToqReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCSToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCSToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3692f0XOa505a3f19f25843c4b3692ef00">
              <SHORT-NAME>IAPASCUReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Shifter Control Unit Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:智驾状态信号
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCUReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCUReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36930fXOa505a3f19f25843c4b36930e00">
              <SHORT-NAME>IAPASCUReqStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Shifter Control Unit Request Status Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:APA请求控制SCU状态有效性信号
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASCUReqStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASCUReqStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASCUReqStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3242f7XOa505a3f19f25843c4b3242f600">
              <SHORT-NAME>IAPASW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">apa_switch_setting</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32316fXOa505a3f19f25843c4b32316e00">
              <SHORT-NAME>IAPASWReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">apa_switch_setting_request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASWReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASWReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASWReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36932eXOa505a3f19f25843c4b36932d00">
              <SHORT-NAME>IAPAShifterPosReqd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Shifter Position Requested</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:智驾请求信号
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAShifterPosReqd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAShifterPosReqd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36934dXOa505a3f19f25843c4b36934c00">
              <SHORT-NAME>IAPAShifterPosReqdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Shifter Position Requested Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:APA请求控制SCU状态有效性信号
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAShifterPosReqdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAShifterPosReqdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAShifterPosReqdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f3a1b413231d69XNa505a3f19f3a1b413231d5800">
              <SHORT-NAME>IAPASpdMdSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Speed Mode Switch Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASpdMdSwSts</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASpdMdSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASpdMdSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36922bXOa505a3f19f25843c4b36922a00">
              <SHORT-NAME>IAPASts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced_Park_Assist_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group12
功能安全:
信息安全:
有无服务标签:
发送方描述:泊车状态机信号
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APASts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APASts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369063XOa505a3f19f25843c4b36906200">
              <SHORT-NAME>IAPAToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAToqReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e7aeXOa505a3f19f25843c4b37e7ad00">
              <SHORT-NAME>IAPATotWhlToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced_Park_Assist_Total_Wheel_Torque_Request_Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group05
功能安全:
信息安全:
有无服务标签:
发送方描述:泊车扭矩请求
接收方描述:PICU/PEU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:PTCANFD
Signal Type:UNM
备注:要求和APAToqReqVal打包在同一个PDU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APATotWhlToqReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APATotWhlToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATotWhlToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36936cXOa505a3f19f25843c4b36936b00">
              <SHORT-NAME>IAPATrgtEPSStrgWhlAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Park Assist Target Electric Power Steering Steering Wheel Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group13
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:APA目标角度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APATrgtEPSStrgWhlAng</SHORT-LABEL>
                  <VALUE>0x8000</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APATrgtEPSStrgWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APATrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369082XOa505a3f19f25843c4b36908100">
              <SHORT-NAME>IAPAVCUReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Apa Vcu Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAVCUReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAVCUReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVCUReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b3dcXOa505a3f19f25843c4b34b3db00">
              <SHORT-NAME>IAPAVehCrdnatAzmth</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced_Park_Assist_Vehicle_Coordinate_Azimuth</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAVehCrdnatAzmth</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAVehCrdnatAzmth</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatAzmth</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b3f7XOa505a3f19f25843c4b34b3f600">
              <SHORT-NAME>IAPAVehCrdnatPosX</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced_Park_Assist_Vehicle_Coordinate_Position_X</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAVehCrdnatPosX</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAVehCrdnatPosX</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosX</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b412XOa505a3f19f25843c4b34b41100">
              <SHORT-NAME>IAPAVehCrdnatPosY</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced_Park_Assist_Vehicle_Coordinate_Position_Y</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>APAVehCrdnatPosY</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/APAVehCrdnatPosY</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAVehCrdnatPosY</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34981aXOa505a3f19f25843c4b34981900">
              <SHORT-NAME>IARHUDPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ARHUD Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:ZXD播报负载配电通断状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ARHUDPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ARHUDPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ARHUDPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3756bfXOa505a3f19f25843c4b3756be00">
              <SHORT-NAME>IASSInhBtnA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Stop Start Inhibit Button Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:（硬开关方案）起停开关，用来识别驾驶员请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ASSInhBtnA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ASSInhBtnA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ASSInhBtnA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375653XOa505a3f19f25843c4b37565200">
              <SHORT-NAME>IASSStsFICM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Stop Start Status Ficm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:（进屏软开关方案）起停开关，用来识别驾驶员请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ASSStsFICM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ASSStsFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ASSStsFICM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375745XOa505a3f19f25843c4b37574400">
              <SHORT-NAME>IASSStsFICMV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Stop Start Status Ficm Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:（进屏软开关方案）起停开关有效性，用来识别驾驶员请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ASSStsFICMV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ASSStsFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ASSStsFICMV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2105XOa505a3f19f25843c4b2e210400">
              <SHORT-NAME>IAVHSigPdlSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AVH Signal Pedal Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:
信息安全:
有无服务标签:
发送方描述:单踏板功能响应状态（D车信号拉起）
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AVHSigPdlSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AVHSigPdlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVHSigPdlSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3231ccXOa505a3f19f25843c4b3231cb00">
              <SHORT-NAME>IAVMDspReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Around_View_Monitor_Display_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AVMDspReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AVMDspReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVMDspReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3233b8XOa505a3f19f25843c4b3233b700">
              <SHORT-NAME>IAVMSt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AVM_Display_Stats</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AVMSt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AVMSt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVMSt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ec3cXOa505a3f19f25843c4b37ec3b00">
              <SHORT-NAME>IAVPMapRutMgIDtReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AVP_Map_Route_Management_ID_Requst</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AVPMapRutMgIDtReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AVPMapRutMgIDtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVPMapRutMgIDtReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e37a6XOa505a3f19f25843c4b2e37a500">
              <SHORT-NAME>IAccelAbsPosOBD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Accelerator Absolute Position On Board Diagnostics</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:ESS,CCU,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelAbsPosOBD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelAbsPosOBD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelAbsPosOBD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3684cbXOa505a3f19f25843c4b3684ca00">
              <SHORT-NAME>IAccelOvrd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Accelerator_Override</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:
信息安全:
有无服务标签:
发送方描述:用户强制ovrd
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelOvrd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelOvrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelOvrd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaf1dXOa505a3f19f25843c4b2eaf1c00">
              <SHORT-NAME>IAccelerationXsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_X</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:X轴向加速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationXsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationXsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationXsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaf3cXOa505a3f19f25843c4b2eaf3b00">
              <SHORT-NAME>IAccelerationXsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_X Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:X轴向加速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationXsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationXsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationXsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaf5bXOa505a3f19f25843c4b2eaf5a00">
              <SHORT-NAME>IAccelerationYsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_Y</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:Y轴向加速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationYsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationYsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationYsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaf7aXOa505a3f19f25843c4b2eaf7900">
              <SHORT-NAME>IAccelerationYsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_Y Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:E2E
信息安全:
有无服务标签:
发送方描述:X轴向角速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationYsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationYsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationYsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaf99XOa505a3f19f25843c4b2eaf9800">
              <SHORT-NAME>IAccelerationZsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_Z</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:Z轴向加速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationZsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationZsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationZsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eafb8XOa505a3f19f25843c4b2eafb700">
              <SHORT-NAME>IAccelerationZsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Acceleration_Z Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:Y轴向加速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AccelerationZsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AccelerationZsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationZsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e15f6XOa505a3f19f25843c4b2e15f500">
              <SHORT-NAME>IActuPnonAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Pinion Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:小齿轮转角
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuPnonAng</SHORT-LABEL>
                  <VALUE>0x8000</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuPnonAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1616XOa505a3f19f25843c4b2e161500">
              <SHORT-NAME>IActuPnonAngV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Pinion Angle Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:小齿轮转角有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuPnonAngV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuPnonAngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuPnonAngV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1635XOa505a3f19f25843c4b2e163400">
              <SHORT-NAME>IActuRoadWhlAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Road Wheel Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:轮边角
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuRoadWhlAng</SHORT-LABEL>
                  <VALUE>0x7F58</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuRoadWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1654XOa505a3f19f25843c4b2e165300">
              <SHORT-NAME>IActuRoadWhlAngGrd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Road Wheel Angle Gradient</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:轮边角速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuRoadWhlAngGrd</SHORT-LABEL>
                  <VALUE>0x7F58</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuRoadWhlAngGrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1673XOa505a3f19f25843c4b2e167200">
              <SHORT-NAME>IActuRoadWhlAngGrdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Road Wheel Angle Gradient Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:轮边角速度有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuRoadWhlAngGrdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuRoadWhlAngGrdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngGrdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1692XOa505a3f19f25843c4b2e169100">
              <SHORT-NAME>IActuRoadWhlAngV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Actual Road Wheel Angle Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:轮边角有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ActuRoadWhlAngV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ActuRoadWhlAngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ActuRoadWhlAngV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3675a0XOa505a3f19f25843c4b36759f00">
              <SHORT-NAME>IAirCtrlrHVILClsd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Controller High Voltage Interlock Loop Closed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group11
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:ESS,CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirCtrlrHVILClsd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirCtrlrHVILClsd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3675bfXOa505a3f19f25843c4b3675be00">
              <SHORT-NAME>IAirCtrlrHVILClsdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Controller High Voltage Interlock Loop Closed Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group11
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:ESS,CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirCtrlrHVILClsdV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirCtrlrHVILClsdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirCtrlrHVILClsdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7639XOa505a3f19f25843c4b2e763800">
              <SHORT-NAME>IAirVentMotPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AirVentMot Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirVentMotPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirVentMotPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirVentMotPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367049XOa505a3f19f25843c4b36704800">
              <SHORT-NAME>IAirbagDpl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag Deployed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:ASIL-B,ASIL A,Y
信息安全:
有无服务标签:
发送方描述:气囊点爆状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:VS，外灯，ESS，CCU,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagDpl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagDpl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDpl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6cccXOa505a3f19f25843c4b2e6ccb00">
              <SHORT-NAME>IAirbagDplForeCall</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag Deployed For Ecall</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagDplForeCall</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagDplForeCall</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplForeCall</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367068XOa505a3f19f25843c4b36706700">
              <SHORT-NAME>IAirbagDplInvsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag Deployed Inversion</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:气囊点爆状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，外灯，ESS，CCU,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagDplInvsn</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagDplInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplInvsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6cedXOa505a3f19f25843c4b2e6cec00">
              <SHORT-NAME>IAirbagDplInvsneForeCall</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag Deployed Inversion For Ecall</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagDplInvsneForeCall</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagDplInvsneForeCall</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplInvsneForeCall</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367087XOa505a3f19f25843c4b36708600">
              <SHORT-NAME>IAirbagSysFlt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag System Fault</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:气囊故障提示,MCB功能使用,安全气囊系统故障
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagSysFlt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagSysFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFlt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e6d0dXOa505a3f19f25843c4b2e6d0c00">
              <SHORT-NAME>IAirbagSysFltForeCall</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag System Fault For Ecall</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagSysFltForeCall</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagSysFltForeCall</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFltForeCall</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3670a6XOa505a3f19f25843c4b3670a500">
              <SHORT-NAME>IAirbagSysFltIndCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Airbag System Fault Indication Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:气囊故障提示,MCB功能使用
接收方描述:SDM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AirbagSysFltIndCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AirbagSysFltIndCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFltIndCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b316c35XOa505a3f19f25843c4b316c3400">
              <SHORT-NAME>IAllWndAndSrfLazyClsReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">All Window And Sunroof Lazy Close Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:RLSS 检测到下雨触发自动关窗请求信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AllWndAndSrfLazyClsReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AllWndAndSrfLazyClsReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AllWndAndSrfLazyClsReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbbe07XNa505a3f19f34f4acdbbbdf800">
              <SHORT-NAME>IAltSigma</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AltSigma</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:IAM_100ms_Group08
功能安全:
信息安全:
有无服务标签:
发送方描述:高度Sigma值
接收方描述:IPD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AltSigma</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AltSigma</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltSigma</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbc14bXNa505a3f19f34f4acdbbc13c00">
              <SHORT-NAME>IAltitudeRTK</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AltitudeRTK</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:IAM_ZONE_100ms_Group40
功能安全:
信息安全:
有无服务标签:
发送方描述:AltitudeRTK
接收方描述:IPD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AltitudeRTK</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AltitudeRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltitudeRTK</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8ccdXOa505a3f19f25843c4b2e8ccc00">
              <SHORT-NAME>IAltngChrgCrntReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Alternating Charge Current Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:大屏下发交流电流设置信号
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AltngChrgCrntReq</SHORT-LABEL>
                  <VALUE>0x20</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AltngChrgCrntReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AltngChrgCrntReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3aeaXOa505a3f19f25843c4b2e3ae900">
              <SHORT-NAME>IAmbtTemSnsrFlrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ambient Temperature Sensor Failure Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AmbtTemSnsrFlrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AmbtTemSnsrFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AmbtTemSnsrFlrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3b09XOa505a3f19f25843c4b2e3b0800">
              <SHORT-NAME>IAmbtTemSnsrFlrStsInvsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Ambient Temperature Sensor Failure Status Inversion</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AmbtTemSnsrFlrStsInvsn</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AmbtTemSnsrFlrStsInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AmbtTemSnsrFlrStsInvsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eafd7XOa505a3f19f25843c4b2eafd600">
              <SHORT-NAME>IAngularRateXsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_X</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:X轴向角速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateXsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateXsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateXsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaff6XOa505a3f19f25843c4b2eaff500">
              <SHORT-NAME>IAngularRateXsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_X Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:Y轴向角速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateXsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateXsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateXsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eb015XOa505a3f19f25843c4b2eb01400">
              <SHORT-NAME>IAngularRateYsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_Y</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:Y轴向角速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateYsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateYsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateYsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eb034XOa505a3f19f25843c4b2eb03300">
              <SHORT-NAME>IAngularRateYsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_Y Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:Z轴向加速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateYsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateYsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateYsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eb053XOa505a3f19f25843c4b2eb05200">
              <SHORT-NAME>IAngularRateZsecinfo</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_Z</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:Z轴向角速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:SNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateZsecinfo</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateZsecinfo</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateZsecinfo</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eb072XOa505a3f19f25843c4b2eb07100">
              <SHORT-NAME>IAngularRateZsecinfoV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Angularrate_Z Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:Y
信息安全:
有无服务标签:
发送方描述:Z轴向角速度有效信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AngularRateZsecinfoV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AngularRateZsecinfoV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateZsecinfoV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b034XOa505a3f19f25843c4b37b03300">
              <SHORT-NAME>IAudiopilotMICSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Audiopilot Microphone Stats</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:Audiopilot 麦克风状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AudiopilotMICSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AudiopilotMICSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AudiopilotMICSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ebc23XOa505a3f19f25843c4b2ebc2200">
              <SHORT-NAME>IAutoChrgngMngmnt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Charging Management</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:自动上高压充电管理
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoChrgngMngmnt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoChrgngMngmnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoChrgngMngmnt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365dabXOa505a3f19f25843c4b365daa00">
              <SHORT-NAME>IAutoHoldMdSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Hold Mode Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:自动驻车开关状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoHoldMdSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoHoldMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMdSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365dcaXOa505a3f19f25843c4b365dc900">
              <SHORT-NAME>IAutoHoldMsg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Hold Message</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:自动保持信息
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoHoldMsg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoHoldMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldMsg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365de9XOa505a3f19f25843c4b365de800">
              <SHORT-NAME>IAutoHoldSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Hold System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:自动保持系统状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoHoldSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoHoldSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoHoldSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b42dXOa505a3f19f25843c4b34b42c00">
              <SHORT-NAME>IAutoLaneChngLLaneSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Lane_Change_Left_Lane_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:ALC左侧变道状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngLLaneSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngLLaneSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngLLaneSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b2f8XOa505a3f19f25843c4b34b2f700">
              <SHORT-NAME>IAutoLaneChngMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Lane Change Message Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBAD_100ms_Group37
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:变道文言提示
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b448XOa505a3f19f25843c4b34b44700">
              <SHORT-NAME>IAutoLaneChngRLaneSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Lane_Change_Right_Lane_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group60
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:ALC右侧变道状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngRLaneSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngRLaneSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngRLaneSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322ffbXOa505a3f19f25843c4b322ffa00">
              <SHORT-NAME>IAutoLaneChngSetReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Lane Change Set Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:ALC风格设置
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngSetReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngSetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSetReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b313XOa505a3f19f25843c4b34b31200">
              <SHORT-NAME>IAutoLaneChngSetResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Lane Change Set Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBAD_100ms_Group37
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:变道风格设置反馈
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngSetResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngSetResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSetResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b32eXOa505a3f19f25843c4b34b32d00">
              <SHORT-NAME>IAutoLaneChngSwDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Lane_Change_Switch_Display_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBAD_100ms_Group37
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:ALC 功能的软开关状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngSwDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSwDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3234cfXOa505a3f19f25843c4b3234ce00">
              <SHORT-NAME>IAutoLaneChngSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Lane_Change_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:ALC软开关请求
接收方描述:ICM-ADAS HMI
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32352cXOa505a3f19f25843c4b32352b00">
              <SHORT-NAME>IAutoLaneChngVcCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Lane Change Voice Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:QM
信息安全:,有无服务标签:
有无服务标签:null
发送方描述:语音变道请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoLaneChngVcCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoLaneChngVcCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngVcCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36597cXOa505a3f19f25843c4b36597b00">
              <SHORT-NAME>IAutoMainBeamLghtOn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Main_Beam_Light_On</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:IHC远光灯开启状态反馈</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoMainBeamLghtOn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoMainBeamLghtOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoMainBeamLghtOn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea3f6XOa505a3f19f25843c4b2ea3f500">
              <SHORT-NAME>IAutoMainBeamLghtReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto main beam light Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:远光灯控制请求
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoMainBeamLghtReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoMainBeamLghtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoMainBeamLghtReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346a04XOa505a3f19f25843c4b346a0300">
              <SHORT-NAME>IAutoMainBeamLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto_Main_Beam_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutoMainBeamLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutoMainBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoMainBeamLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c488XOa505a3f19f25843c4b34c48700">
              <SHORT-NAME>IAutocParkngSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auto Parking Switch Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group13
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutocParkngSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutocParkngSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocParkngSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376706XOa505a3f19f25843c4b37670500">
              <SHORT-NAME>IAutocTrCmddGear_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutocTrCmddGear_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutocTrCmddGear_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrCmddGear_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376bb8XOa505a3f19f25843c4b376bb700">
              <SHORT-NAME>IAutocTrGearShftDircn</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutocTrGearShftDircn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutocTrGearShftDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376bcfXOa505a3f19f25843c4b376bce00">
              <SHORT-NAME>IAutocTrGearShftDircnF</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutocTrGearShftDircnF</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutocTrGearShftDircnF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrGearShftDircnF</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3237d6XOa505a3f19f25843c4b3237d500">
              <SHORT-NAME>IAutodDrvngSysEmgcBrkReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated_Driving_System_Emergency_Brake_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysEmgcBrkReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysEmgcBrkReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3237f5XOa505a3f19f25843c4b3237f400">
              <SHORT-NAME>IAutodDrvngSysEmgcBrkReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated_Driving_System_Emergency_Brake_Request_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysEmgcBrkReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysEmgcBrkReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysEmgcBrkReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b168XOa505a3f19f25843c4b34b16700">
              <SHORT-NAME>IAutodDrvngSysFlrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Failure Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysFlrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysFlrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b183XOa505a3f19f25843c4b34b18200">
              <SHORT-NAME>IAutodDrvngSysFlrStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Failure Status Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysFlrStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysFlrStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysFlrStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b19eXOa505a3f19f25843c4b34b19d00">
              <SHORT-NAME>IAutodDrvngSysMdReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Mode Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysMdReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366735XOa505a3f19f25843c4b36673400">
              <SHORT-NAME>IAutodDrvngSysMdReqResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Mode Request Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysMdReqResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysMdReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366754XOa505a3f19f25843c4b36675300">
              <SHORT-NAME>IAutodDrvngSysMdReqRespV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Mode Request Response Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysMdReqRespV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysMdReqRespV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqRespV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b1b9XOa505a3f19f25843c4b34b1b800">
              <SHORT-NAME>IAutodDrvngSysMdReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Mode Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysMdReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysMdReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysMdReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b1d4XOa505a3f19f25843c4b34b1d300">
              <SHORT-NAME>IAutodDrvngSysSCSDrvOffReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Stability Control System Drive Off Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysSCSDrvOffReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysSCSDrvOffReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b1efXOa505a3f19f25843c4b34b1ee00">
              <SHORT-NAME>IAutodDrvngSysSCSDrvOffReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Stability Control System Drive Off Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysSCSDrvOffReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysSCSDrvOffReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSDrvOffReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b20aXOa505a3f19f25843c4b34b20900">
              <SHORT-NAME>IAutodDrvngSysSCSSdslReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Stability Control System Standstill Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysSCSSdslReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysSCSSdslReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b225XOa505a3f19f25843c4b34b22400">
              <SHORT-NAME>IAutodDrvngSysSCSSdslReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Stability Control System Standstill Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysSCSSdslReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysSCSSdslReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSCSSdslReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36924aXOa505a3f19f25843c4b36924900">
              <SHORT-NAME>IAutodDrvngSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated_Driving_System_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBAD_20ms_Group12
功能安全:
信息安全:
有无服务标签:
发送方描述:智驾系统状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31adbeXOa505a3f19f25843c4b31adbd00">
              <SHORT-NAME>IAutodDrvngSysStsPT</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Status PT</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group15
功能安全:需要RC\CRC通讯校验
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysStsPT</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysStsPT</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsPT</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b2b7XOa505a3f19f25843c4b34b2b600">
              <SHORT-NAME>IAutodDrvngSysStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated Driving System Status Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group12
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngSysStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngSysStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaef3XOa505a3f19f25843c4b2eaef200">
              <SHORT-NAME>IAutodDrvngToqReqResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automated_Driving_Torque_Request_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:RZCU_10ms_Group23
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:低速智驾反馈
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AutodDrvngToqReqResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AutodDrvngToqReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngToqReqResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b1f010XNa505a3f19f5902a13b1f00100">
              <SHORT-NAME>IAuxBatUnAssembled</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Auxiliary Battery UnAssemled</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group19
功能安全:
信息安全:
有无服务标签:
发送方描述:辅电池桩头是否安装状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AuxBatUnAssembled</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AuxBatUnAssembled</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AuxBatUnAssembled</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32337aXOa505a3f19f25843c4b32337900">
              <SHORT-NAME>IAvgFuelCsump</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Average Fuel Consumption</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:32960.0</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AvgFuelCsump</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AvgFuelCsump</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AvgFuelCsump</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7677XOa505a3f19f25843c4b2e767600">
              <SHORT-NAME>IAvgFuelCsumpPrcs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Average Fuel Consumption Precision</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:
功能安全:N
信息安全:
有无服务标签:
发送方描述:自启动平均燃油消耗率，用于RVM国标发动机数据的上传
接收方描述:IAM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:RVM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AvgFuelCsumpPrcs</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AvgFuelCsumpPrcs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AvgFuelCsumpPrcs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7696XOa505a3f19f25843c4b2e769500">
              <SHORT-NAME>IAvgFuelCsumpPrcsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Average Fuel Consumption Precision Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:
功能安全:N
信息安全:
有无服务标签:
发送方描述:自启动平均燃油消耗率，用于RVM国标发动机数据的上传
接收方描述:IAM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:RVM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AvgFuelCsumpPrcsV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AvgFuelCsumpPrcsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AvgFuelCsumpPrcsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323434XOa505a3f19f25843c4b32343300">
              <SHORT-NAME>IAvgFuelCsumpV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Average Fuel Consumption Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:32960.0</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AvgFuelCsumpV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AvgFuelCsumpV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AvgFuelCsumpV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e25faXOa505a3f19f25843c4b2e25f900">
              <SHORT-NAME>IBCMOdoReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Body Control Module Odometer Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ODO学习请求
接收方描述:ZXDVC
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BCMOdoReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BCMOdoReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BCMOdoReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e02d3XOa505a3f19f25843c4b2e02d200">
              <SHORT-NAME>IBMSCdstCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Coldstart Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSCdstCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSCdstCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSCdstCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0ad1XOa505a3f19f25843c4b2e0ad000">
              <SHORT-NAME>IBMSChrgTrgtStdAvlblEnrg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Charge Target Standard Available Energy</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包目标充电截止CLTC工况可用能量,IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSChrgTrgtStdAvlblEnrg</SHORT-LABEL>
                  <VALUE>0xFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSChrgTrgtStdAvlblEnrg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSChrgTrgtStdAvlblEnrg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e07caXOa505a3f19f25843c4b2e07c900">
              <SHORT-NAME>IBMSChrgTrgtStdAvlblEnrgV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Charge Target Standard Available Energy Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包目标充电截止CLTC工况可用能量有效位，IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSChrgTrgtStdAvlblEnrgV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSChrgTrgtStdAvlblEnrgV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSChrgTrgtStdAvlblEnrgV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0238XOa505a3f19f25843c4b2e023700">
              <SHORT-NAME>IBMSDisTrgtStdAvlblEnrg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Discharge Standard CLTC Available Energy</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包目标放电截止CLTC工况可用能量
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSDisTrgtStdAvlblEnrg</SHORT-LABEL>
                  <VALUE>0xFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSDisTrgtStdAvlblEnrg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSDisTrgtStdAvlblEnrg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0a36XOa505a3f19f25843c4b2e0a3500">
              <SHORT-NAME>IBMSDisTrgtStdAvlblEnrgV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Discharge Standard CLTC Available Energy Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包目标放电截止CLTC工况可用能量有效位
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSDisTrgtStdAvlblEnrgV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSDisTrgtStdAvlblEnrgV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSDisTrgtStdAvlblEnrgV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2de915XOa505a3f19f25843c4b2de91400">
              <SHORT-NAME>IBMSEmsnRltdMalfA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Emissions Related Malfunction Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSEmsnRltdMalfA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSEmsnRltdMalfA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSEmsnRltdMalfA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2de972XOa505a3f19f25843c4b2de97100">
              <SHORT-NAME>IBMSFltLamp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Fault Lamp</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:动力电池故障指示灯
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:ESS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSFltLamp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSFltLamp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSFltLamp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2dfe8bXOa505a3f19f25843c4b2dfe8a00">
              <SHORT-NAME>IBMSNegPtIsltnRstc</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Negative Powertrain Isolation Resistance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group25
功能安全:ASIL-B,Y
信息安全:
有无服务标签:
发送方描述:BMS输出电池包负极对地绝缘电阻值
接收方描述:BMS输出电池包负极对地绝缘电阻值
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSNegPtIsltnRstc</SHORT-LABEL>
                  <VALUE>0x3FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSNegPtIsltnRstc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSNegPtIsltnRstc</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2dfeaaXOa505a3f19f25843c4b2dfea900">
              <SHORT-NAME>IBMSNegPtIsltnRstcV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Negative Powertrain Isolation Resistance Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:BMS输出电池包负极对地绝缘电阻值有效位
接收方描述:BMS输出电池包负极对地绝缘电阻值有效位
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSNegPtIsltnRstcV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSNegPtIsltnRstcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSNegPtIsltnRstcV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0ca2XOa505a3f19f25843c4b2e0ca100">
              <SHORT-NAME>IBMSOdoFct</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Odometer Factor</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOdoFct</SHORT-LABEL>
                  <VALUE>0xFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOdoFct</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOdoFct</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0295XOa505a3f19f25843c4b2e029400">
              <SHORT-NAME>IBMSOdoFctV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Odometer Factor Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOdoFctV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOdoFctV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOdoFctV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367817XOa505a3f19f25843c4b36781600">
              <SHORT-NAME>IBMSOfbdChrgrSktVol</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Off-board Charger Socket Voltage</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group58
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOfbdChrgrSktVol</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOfbdChrgrSktVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVol</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367836XOa505a3f19f25843c4b36783500">
              <SHORT-NAME>IBMSOfbdChrgrSktVolV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Off-board Charger Socket Voltage Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group58
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOfbdChrgrSktVolV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOfbdChrgrSktVolV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOfbdChrgrSktVolV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367855XOa505a3f19f25843c4b36785400">
              <SHORT-NAME>IBMSOffBdChrgrPlugOn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Off Board Charger Plug On</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group58
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOffBdChrgrPlugOn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOffBdChrgrPlugOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367874XOa505a3f19f25843c4b36787300">
              <SHORT-NAME>IBMSOffBdChrgrPlugOnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Off Board Charger Plug On Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group58
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:CCU,IBS,PICU，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOffBdChrgrPlugOnV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOffBdChrgrPlugOnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOffBdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b319454XOa505a3f19f25843c4b31945300">
              <SHORT-NAME>IBMSOnbdChrgSpRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Onboard Charge Stop Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:慢充中止原因
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSOnbdChrgSpRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSOnbdChrgSpRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSOnbdChrgSpRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2deec5XOa505a3f19f25843c4b2deec400">
              <SHORT-NAME>IBMSPackSOH</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Pack State Of Health</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:ESS,CCU,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSPackSOH</SHORT-LABEL>
                  <VALUE>0x3FE</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSPackSOH</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSPackSOH</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2dfec9XOa505a3f19f25843c4b2dfec800">
              <SHORT-NAME>IBMSPosPtIsltnRstc</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Positive Powertrain Isolation Resistance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group25
功能安全:ASIL-B,Y
信息安全:
有无服务标签:
发送方描述:BMS输出电池包正极对地绝缘电阻值
接收方描述:BMS输出电池包正极对地绝缘电阻值
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSPosPtIsltnRstc</SHORT-LABEL>
                  <VALUE>0x3FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSPosPtIsltnRstc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSPosPtIsltnRstc</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2dfee8XOa505a3f19f25843c4b2dfee700">
              <SHORT-NAME>IBMSPosPtIsltnRstcV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Postive Powertrain Isolation Resistance Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ESS_100ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:BMS输出电池包正极对地绝缘电阻值有效位
接收方描述:BMS输出电池包正极对地绝缘电阻值有效位
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSPosPtIsltnRstcV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSPosPtIsltnRstcV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSPosPtIsltnRstcV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2df286XOa505a3f19f25843c4b2df28500">
              <SHORT-NAME>IBMSStaOfHealthCapct</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System State Of Health Capacity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSStaOfHealthCapct</SHORT-LABEL>
                  <VALUE>0xFE</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSStaOfHealthCapct</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSStaOfHealthCapct</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2df2a5XOa505a3f19f25843c4b2df2a400">
              <SHORT-NAME>IBMSStaOfHealthResi</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System State Of Health Resistance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSStaOfHealthResi</SHORT-LABEL>
                  <VALUE>0xFE</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSStaOfHealthResi</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSStaOfHealthResi</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e055eXOa505a3f19f25843c4b2e055d00">
              <SHORT-NAME>IBMSStdAvlblEnrg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Standard Available Energy</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包当前CLTC工况可用能量,IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSStdAvlblEnrg</SHORT-LABEL>
                  <VALUE>0xFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSStdAvlblEnrg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSStdAvlblEnrg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e0a93XOa505a3f19f25843c4b2e0a9200">
              <SHORT-NAME>IBMSStdAvlblEnrgV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Management System Standard Available Energy Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:电池包当前CLTC工况可用能量有效位，IBMS
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EV ESS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BMSStdAvlblEnrgV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BMSStdAvlblEnrgV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BMSStdAvlblEnrgV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9652XOa505a3f19f25843c4b2e965100">
              <SHORT-NAME>IBPEPSPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">BPEPS Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM平台化需求</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BPEPSPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BPEPSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BPEPSPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36944fXOa505a3f19f25843c4b36944e00">
              <SHORT-NAME>IBPMMstrAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Backup_Power_Mode_Master_Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:AMP,AMR,BCM,BPEPS,CARLog,CCU,DLP,EOPC,EPMCU,EPS,ESS,FDR,FLDCM,FLSM,FRDCM,FRSM,IAM,IBS,ICM,IMATE,IMCU,IMU,IPD,ITMS,LFSDA,LHCMS,LHRDA,LVBM,PLCM,PMA,RFSDA,RHCMS,RHRDA,RLDCM,RLSM,RRDCM,RRSM,SAC,SAS,SCM,SCU,SDM,WLC
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BPMMstrAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BPMMstrAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BPMMstrAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3231ebXOa505a3f19f25843c4b3231ea00">
              <SHORT-NAME>IBSDSelReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Blind Spot Detect Select Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BSDSelReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BSDSelReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BSDSelReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee957XOa505a3f19f25843c4b2ee95600">
              <SHORT-NAME>IBSDSelSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Blind Spot Detect Select Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RHRDA_50ms_Group04
功能安全:
信息安全:
有无服务标签:null
发送方描述:软开关显示状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BSDSelSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BSDSelSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BSDSelSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36890eXOa505a3f19f25843c4b36890d00">
              <SHORT-NAME>IBarPrsAbs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Barometric Pressure Absolute</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:ECM_500ms_group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BarPrsAbs</SHORT-LABEL>
                  <VALUE>0xc8</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BarPrsAbs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36892eXOa505a3f19f25843c4b36892d00">
              <SHORT-NAME>IBarPrsAbsOBD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Barometric Pressure Absolute On Board Diagnostics</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:ECM_500ms_group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BarPrsAbsOBD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BarPrsAbsOBD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsOBD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36894eXOa505a3f19f25843c4b36894d00">
              <SHORT-NAME>IBarPrsAbsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Barometric Pressure Absolute Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:ECM_500ms_group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BarPrsAbsV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BarPrsAbsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BarPrsAbsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317f96XOa505a3f19f25843c4b317f9500">
              <SHORT-NAME>IBaseLineLen</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">BaseLineLength</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:主从天线间距
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BaseLineLen</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BaseLineLen</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BaseLineLen</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e76b5XOa505a3f19f25843c4b2e76b400">
              <SHORT-NAME>IBatVol</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Battery Voltage</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BatVol</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>14</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BatVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BatVol</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346a55XOa505a3f19f25843c4b346a5400">
              <SHORT-NAME>IBklghtReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">BackLight Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:伴我回家请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BklghtReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BklghtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BklghtReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2619XOa505a3f19f25843c4b2e261800">
              <SHORT-NAME>IBntOpenSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Bonnet Open Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:门锁信号，前舱盖状态反馈功能
接收方描述:BntLatchDrvMdl
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:门锁，音响,SDM,IBS,AC，空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BntOpenSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BntOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BntOpenSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366ee5XOa505a3f19f25843c4b366ee400">
              <SHORT-NAME>IBrkBstFnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Boost Function Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_ZONE_20ms_Group08
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:底盘辅助制动系统响应状态反馈
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkBstFnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkBstFnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkBstFnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2124XOa505a3f19f25843c4b2e212300">
              <SHORT-NAME>IBrkDiscTemSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Disc Temperature Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动盘温度状态
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkDiscTemSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkDiscTemSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkDiscTemSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373e1aXOa505a3f19f25843c4b373e1900">
              <SHORT-NAME>IBrkFltAlrm_GB</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake system Alarm GB</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:IBS_100ms_Group15
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:32960.0</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkFltAlrm_GB</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkFltAlrm_GB</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFltAlrm_GB</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2143XOa505a3f19f25843c4b2e214200">
              <SHORT-NAME>IBrkFludLvlLow</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Fluid Level Low</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动液状态
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkFludLvlLow</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkFludLvlLow</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLow</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2162XOa505a3f19f25843c4b2e216100">
              <SHORT-NAME>IBrkFludLvlLowV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Fluid Level Low Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动液状态有效性
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkFludLvlLowV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkFludLvlLowV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFludLvlLowV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373e39XOa505a3f19f25843c4b373e3800">
              <SHORT-NAME>IBrkFrc_GB</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake system Force status GB</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:IBS_100ms_Group15
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:32960.0</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkFrc_GB</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkFrc_GB</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkFrc_GB</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2638XOa505a3f19f25843c4b2e263700">
              <SHORT-NAME>IBrkLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯控制
接收方描述:制动灯控制
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c07dXOa505a3f19f25843c4b37c07c00">
              <SHORT-NAME>IBrkLghtF_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Light Failed_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光故障状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtF_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtF_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b461XOa505a3f19f25843c4b37b46000">
              <SHORT-NAME>IBrkLghtFltSta</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_Fault_State</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯故障状态
接收方描述:ZXD,RZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtFltSta</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtFltSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtFltSta</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b813XOa505a3f19f25843c4b34b81200">
              <SHORT-NAME>IBrkLghtFltSts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_Fault_Status_HardWired</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯故障状态
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtFltSts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtFltSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtFltSts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c099XOa505a3f19f25843c4b37c09800">
              <SHORT-NAME>IBrkLghtOn_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Light On_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光开启状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtOn_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtOn_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtOn_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b47cXOa505a3f19f25843c4b37b47b00">
              <SHORT-NAME>IBrkLghtSta</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_State</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:LHZCU_50ms_Group24
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtSta</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSta</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b82eXOa505a3f19f25843c4b34b82d00">
              <SHORT-NAME>IBrkLghtSts_HW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Light Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯状态
接收方描述:ZXD,LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtSts_HW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtSts_HW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSts_HW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3782c7XOa505a3f19f25843c4b3782c600">
              <SHORT-NAME>IBrkLghtSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯开关请求
接收方描述:制动灯开关请求
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2657XOa505a3f19f25843c4b2e265600">
              <SHORT-NAME>IBrkLghtSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Light Switch Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯开关状态
接收方描述:制动灯开关状态
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2676XOa505a3f19f25843c4b2e267500">
              <SHORT-NAME>IBrkLghtSwStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Light_Switch _Status_Validty</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:制动灯开关有效性信号有效性，做防盗功能
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkLghtSwStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkLghtSwStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSwStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2181XOa505a3f19f25843c4b2e218000">
              <SHORT-NAME>IBrkPdlAppd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Applied</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动踏板状态
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlAppd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlAppd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e21a0XOa505a3f19f25843c4b2e219f00">
              <SHORT-NAME>IBrkPdlAppdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Applied Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动踏板状态有效性
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlAppdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlAppdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlAppdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e21bfXOa505a3f19f25843c4b2e21be00">
              <SHORT-NAME>IBrkPdlDrvrAppdPrs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Driver Applied Pressure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动踏板压力
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlDrvrAppdPrs</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlDrvrAppdPrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e21deXOa505a3f19f25843c4b2e21dd00">
              <SHORT-NAME>IBrkPdlDrvrAppdPrsDet</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Pedal_Driver_Applied_Pressure_Detected</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:产品定义的SCM子功能需求，制动压力检测
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlDrvrAppdPrsDet</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlDrvrAppdPrsDet</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDet</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e21fdXOa505a3f19f25843c4b2e21fc00">
              <SHORT-NAME>IBrkPdlDrvrAppdPrsDetV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake_Pedal_Driver_Applied_Pressure_Detected_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:产品定义的SCM子功能需求，制动压力检测有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlDrvrAppdPrsDetV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlDrvrAppdPrsDetV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsDetV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e221cXOa505a3f19f25843c4b2e221b00">
              <SHORT-NAME>IBrkPdlDrvrAppdPrsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Driver Applied Pressure Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动踏板压力有效性
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlDrvrAppdPrsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlDrvrAppdPrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlDrvrAppdPrsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e223bXOa505a3f19f25843c4b2e223a00">
              <SHORT-NAME>IBrkPdlMdlActSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Model Actual Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:制动踏板实际模式
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlMdlActSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlMdlActSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlActSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e225aXOa505a3f19f25843c4b2e225900">
              <SHORT-NAME>IBrkPdlMdlSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Model Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:制动踏板模式
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlMdlSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlMdlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlMdlSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2279XOa505a3f19f25843c4b2e227800">
              <SHORT-NAME>IBrkPdlPos</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group04
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:制动开度,制动踏板开度
接收方描述:EDR 制动踏板位置信号,ICBAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2298XOa505a3f19f25843c4b2e229700">
              <SHORT-NAME>IBrkPdlPosV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Position Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group04
功能安全:Y
信息安全:
有无服务标签:
发送方描述:valid,制动踏板开度
接收方描述:EDR 制动踏板位置信号,ICBAD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlPosV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlPosV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e22b7XOa505a3f19f25843c4b2e22b600">
              <SHORT-NAME>IBrkPdlSimltdPrs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Simulated Pressure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:制动踏板计算压力
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlSimltdPrs</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlSimltdPrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e22d6XOa505a3f19f25843c4b2e22d500">
              <SHORT-NAME>IBrkPdlSimltdPrsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Simulated Pressure Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group10
功能安全:Y
信息安全:
有无服务标签:
发送方描述:制动踏板计算压力有效性
接收方描述:ICBAD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlSimltdPrsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlSimltdPrsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlSimltdPrsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3177f4XOa505a3f19f25843c4b3177f300">
              <SHORT-NAME>IBrkPdlTrigd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Pedal Triggerd</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:制动踏板踩下动作
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:VS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkPdlTrigd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkPdlTrigd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkPdlTrigd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e76d4XOa505a3f19f25843c4b2e76d300">
              <SHORT-NAME>IBrkSwPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">BrkSw Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSwPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSwPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSwPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e22f5XOa505a3f19f25843c4b2e22f400">
              <SHORT-NAME>IBrkSysBrkLghtsReqd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Brake Lights Requested</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:IBS_10ms_Group04
功能安全:
信息安全:
有无服务标签:
发送方描述:制动系统制动灯请求,制动灯点亮请求
接收方描述:制动系统制动灯请求
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:外灯,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysBrkLghtsReqd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysBrkLghtsReqd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysBrkLghtsReqd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3744b4XOa505a3f19f25843c4b3744b300">
              <SHORT-NAME>IBrkSysHillRlbkCtrlAvlbl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Hill Rollback Control Available</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:IBS
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysHillRlbkCtrlAvlbl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysHillRlbkCtrlAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillRlbkCtrlAvlbl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b374738XOa505a3f19f25843c4b37473700">
              <SHORT-NAME>IBrkSysHillRlbkCtrlSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Hill Rollback Control Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:IBS
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysHillRlbkCtrlSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysHillRlbkCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillRlbkCtrlSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365e08XOa505a3f19f25843c4b365e0700">
              <SHORT-NAME>IBrkSysHillStAstAvlbl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Hill Start Assist Available</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:制动系统坡道起步辅助可用性
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysHillStAstAvlbl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysHillStAstAvlbl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstAvlbl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365e27XOa505a3f19f25843c4b365e2600">
              <SHORT-NAME>IBrkSysHillStAstSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Hill Start Assist Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:制动系统坡道起步辅助状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysHillStAstSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysHillStAstSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysHillStAstSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2315XOa505a3f19f25843c4b2e231400">
              <SHORT-NAME>IBrkSysRddySysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake Redundancy System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:制动冗余整体系统状态指示
接收方描述:DLP,FDR,IAM,ICC,IPD,LFSDA,LHRDA,RFSDA,RHRDA,Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysRddySysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysRddySysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRddySysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365e46XOa505a3f19f25843c4b365e4500">
              <SHORT-NAME>IBrkSysRedBrkTlltReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Red Brake Telltale Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:制动系统红色制动信号灯请求
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysRedBrkTlltReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysRedBrkTlltReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysRedBrkTlltReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365e65XOa505a3f19f25843c4b365e6400">
              <SHORT-NAME>IBrkSysYlwBrkTlltReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Brake System Yellow Brake Telltale Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:制动系统黄色制动信号灯请求
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>BrkSysYlwBrkTlltReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/BrkSysYlwBrkTlltReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkSysYlwBrkTlltReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31865eXOa505a3f19f25843c4b31865d00">
              <SHORT-NAME>ICANprotocolinternalversion</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CANprotocolinternalversion</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:CAN内部协议，预留为0
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CANprotocolinternalversion</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CANprotocolinternalversion</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CANprotocolinternalversion</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bd6fXOa505a3f19f25843c4b34bd6e00">
              <SHORT-NAME>ICCDisAdjtVcCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Distance_Adjust_Voice_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:语音调时距
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCDisAdjtVcCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCDisAdjtVcCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisAdjtVcCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8ff4XOa505a3f19f25843c4b2e8ff300">
              <SHORT-NAME>ICCDisDecAndIncVcCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Distance_Decrease_And_Increase_Voice_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCDisDecAndIncVcCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCDisDecAndIncVcCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCDisDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b971XOa505a3f19f25843c4b36b97000">
              <SHORT-NAME>ICCEOPAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCU Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCEOPAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCEOPAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCEOPAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9013XOa505a3f19f25843c4b2e901200">
              <SHORT-NAME>ICCSpdDecAndIncVcCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Speed_Decrease_And_Increase_Voice_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSpdDecAndIncVcCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSpdDecAndIncVcCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdDecAndIncVcCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bd8aXOa505a3f19f25843c4b34bd8900">
              <SHORT-NAME>ICCSpdVcCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Speed_Voice_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:语音调速
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSpdVcCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSpdVcCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3462a1XOa505a3f19f25843c4b3462a000">
              <SHORT-NAME>ICCSpdVcCmdCnfm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Speed_Voice_Command_Confirm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:语音反馈状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSpdVcCmdCnfm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSpdVcCmdCnfm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmdCnfm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9032XOa505a3f19f25843c4b2e903100">
              <SHORT-NAME>ICCSpdVcCmdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Speed_Voice_Command_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSpdVcCmdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSpdVcCmdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea415XOa505a3f19f25843c4b2ea41400">
              <SHORT-NAME>ICCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Speed_Voice_Command_Switch_Request_Display_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSpdlVcCmdSwReqDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSpdlVcCmdSwReqDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdlVcCmdSwReqDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9051XOa505a3f19f25843c4b2e905000">
              <SHORT-NAME>ICCSwStsCCASwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Switch_Status_Cruise_Control_Active_Switch_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsCCASwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsCCASwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCCASwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e90d1XOa505a3f19f25843c4b2e90d000">
              <SHORT-NAME>ICCSwStsCanclSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCSw Sts Cancl Sw A</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsCanclSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsCanclSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsCanclSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e90f0XOa505a3f19f25843c4b2e90ef00">
              <SHORT-NAME>ICCSwStsDistDecSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Switch_Status_Distance_Decrease_Switch_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsDistDecSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsDistDecSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistDecSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e910fXOa505a3f19f25843c4b2e910e00">
              <SHORT-NAME>ICCSwStsDistIncSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Switch_Status_Distance_Increase_Switch_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsDistIncSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsDistIncSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsDistIncSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e912eXOa505a3f19f25843c4b2e912d00">
              <SHORT-NAME>ICCSwStsOnSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCSw Sts On Sw A</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsOnSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsOnSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsOnSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e914dXOa505a3f19f25843c4b2e914c00">
              <SHORT-NAME>ICCSwStsRsmSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCSw Sts Rsm Sw A</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsRsmSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsRsmSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsRsmSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9070XOa505a3f19f25843c4b2e906f00">
              <SHORT-NAME>ICCSwStsSetSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise Control Switch Status Set Switch Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):30.0
Signal Group:ICBVC_30ms_Group158
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsSetSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsSetSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSetSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e916cXOa505a3f19f25843c4b2e916b00">
              <SHORT-NAME>ICCSwStsSpdDecSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Switch_Status_Speed_Decrease_Switch_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsSpdDecSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsSpdDecSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdDecSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e918bXOa505a3f19f25843c4b2e918a00">
              <SHORT-NAME>ICCSwStsSpdIncSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Cruise_Control_Switch_Status_Speed_Increase_Switch_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾，巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsSpdIncSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsSpdIncSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSpdIncSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e91aaXOa505a3f19f25843c4b2e91a900">
              <SHORT-NAME>ICCSwStsSwDataIntgty</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCSw Sts Sw Data Intgty</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:巡航开关</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCSwStsSwDataIntgty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCSwStsSwDataIntgty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSwStsSwDataIntgty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4ba3b8c9XOa505a3f19f25843c4ba3b8ba00">
              <SHORT-NAME>ICCUActiveWkup</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCUActive Wakeup</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group07
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUActiveWkup</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUActiveWkup</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUActiveWkup</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3675deXOa505a3f19f25843c4b3675dd00">
              <SHORT-NAME>ICCUClntFlowReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Coolant Flow Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group11
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUClntFlowReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUClntFlowReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUClntFlowReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f3a1b41322e7e3XNa505a3f19f3a1b41322e7d200">
              <SHORT-NAME>ICCUInnrDschrgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Inner Discharge Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:N
信息安全:N
有无服务标签:N
发送方描述:车内放电请求
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUInnrDschrgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUInnrDschrgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUInnrDschrgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c959XOa505a3f19f25843c4b37c95800">
              <SHORT-NAME>ICCUInnrDschrgSpRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCU Inner Dischargering Stop Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:N
信息安全:N
有无服务标签:N
发送方描述:CCU车内放电停止原因
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUInnrDschrgSpRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUInnrDschrgSpRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUInnrDschrgSpRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c9dfXOa505a3f19f25843c4b37c9de00">
              <SHORT-NAME>ICCUInnrDschrgplugin</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">CCU inner Discharger plug in</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:N
信息安全:N
有无服务标签:N
发送方描述:插入检测信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUInnrDschrgplugin</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUInnrDschrgplugin</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUInnrDschrgplugin</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4ba3b8f4XOa505a3f19f25843c4ba3b8e500">
              <SHORT-NAME>ICCUOnbdChrgrMaxChrgPwr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Onboard Charger Maximum Charge Power</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group07
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUOnbdChrgrMaxChrgPwr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUOnbdChrgrMaxChrgPwr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrMaxChrgPwr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4ba3b91dXOa505a3f19f25843c4ba3b90e00">
              <SHORT-NAME>ICCUOnbdChrgrPlugOn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Onboard Charger Plug On</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group07
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:ESS,CCU,IBS,PICU，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUOnbdChrgrPlugOn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUOnbdChrgrPlugOn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4ba3b946XOa505a3f19f25843c4ba3b93700">
              <SHORT-NAME>ICCUOnbdChrgrPlugOnV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Onboard Charger Plug On Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group07
功能安全:
信息安全:
有无服务标签:
发送方描述:功能安全需求
接收方描述:PICM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUOnbdChrgrPlugOnV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUOnbdChrgrPlugOnV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCUOnbdChrgrPlugOnV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3675fdXOa505a3f19f25843c4b3675fc00">
              <SHORT-NAME>ICCUOnbdChrgrSktEleccLckEnable</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Combined Charging Unit Onboard Charger Socket Electric Lock Enable</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:CCU_100ms_Group11
功能安全:QM
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>CCUOnbdChrgrSktEleccLckEnable</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/CCUOnbdChrgrSktEleccLckEnable</COMPU-METHOD-REF>
