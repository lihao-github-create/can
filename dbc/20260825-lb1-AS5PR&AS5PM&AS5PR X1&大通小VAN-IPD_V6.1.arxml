                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f67ad00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved23</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f65ac00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChrgrFlapLtchCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f661800">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f67c800">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved31</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f681900">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved34</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f664e00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f67fe00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved36</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f663300">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f67e300">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved38</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>38</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f65fd00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f675c00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtFltsts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f672600">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtFltsts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f66ba00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRearFogLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f66d500">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRearFogLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f66f000">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtFltSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f656200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f666900">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrLftgtClsSwtActv</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f659100">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f674100">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtSts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f677700">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtSts_HW</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f65c700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f670b00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f65e200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f683400">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f6540xOa505a3f19f25843c4b2f657e00">
                  <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IRZCU_50ms_Group37</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f267aXOa505a3f19f25843c4b2f267900">
              <SHORT-NAME>SDM_100ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_100ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f268c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>1</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f26a800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISeatOccptnNum</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f26de00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecRowMOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f26c300">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecRowLOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f271400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdRowLOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f274a00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdRowROccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f272f00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrdRowMOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f267axOa505a3f19f25843c4b2f26f900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecRowROccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f1f96XOa505a3f19f25843c4b2f1f9500">
              <SHORT-NAME>SDM_20ms_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>657153</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.015</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/AirbagDplForeCall</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU01/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f200500">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f202000">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f231300">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f203b00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltForeCall</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f1fea00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsneForeCall</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f1fbb00">
                  <SHORT-NAME>AirbagDplForeCall</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplForeCall</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f20c200">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSbltAudRmndr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f20a700">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtPsngSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f208c00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f232d00">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f207100">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f205600">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f214900">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f212e00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f20f800">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f20dd00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f211300">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f216400">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f220600">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f21eb00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f21d000">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f21b500">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f219a00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>38</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f217f00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f22a800">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f228d00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f227200">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f225700">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f223c00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f222100">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f22de00">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f22c300">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f234700">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f236100">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f22f900">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmdEvtTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1f96xOa505a3f19f25843c4b2f1fd600">
                  <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f2411XOa505a3f19f25843c4b2f241000">
              <SHORT-NAME>SDM_20ms_PDU02</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>657154</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.015</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/AirbagDpl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU02/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f247e00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f249900">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f24cf00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f246300">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f243300">
                  <SHORT-NAME>AirbagDpl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDpl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e90130b2c00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved16</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f257100">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f255600">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f258c00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysIndrCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f24b400">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFlt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f253b00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9011e0ae00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltIndCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9011e07a00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9011e09400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtcV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e90130df800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved31</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e901310d100">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved37</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9011e00900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMOccupntSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9013139300">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved47</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9013165800">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved51</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f252000">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagIndReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f250500">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagEnbIndF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f24ea00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagDsblIndF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e90131bed00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved57</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f25a700">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehCrshTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xN200000119f58e5e9013192800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f2411xOa505a3f19f25843c4b2f244f00">
                  <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f27b7XOa505a3f19f25843c4b2f27b600">
              <SHORT-NAME>SDM_20ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/SDM_20ms_PDU03/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f281400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f282f00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f28b600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f27c900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRate_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f284a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAcc_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f288000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAcc_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f28ec00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f286500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAccV_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f27f900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRateV_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f289b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAccV_SDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f28d100">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f290700">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f27b7xOa505a3f19f25843c4b2f27e500">
                  <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b34d069XOa505a3f19f25843c4b34d06800">
              <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_020ms_PDU18/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d0e000">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d0fb00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d14c00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve03</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d0c500">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICluActTorq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d07b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUAPAUnderCtrlA_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d16700">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrAPACanclReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d11600">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve01</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>38</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d0aa00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvrIntrvnA_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d13100">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve02</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b34d069xOa505a3f19f25843c4b34d09700">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_020ms_PDU18</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b342c4eXOa505a3f19f25843c4b342c4d00">
              <SHORT-NAME>TCM_025ms_PDU02</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/AutocTrCmddGear_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/DrvrShftCtrlReqDndIO</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/DrvrShftCtrlTrgtGear_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TCM_025ms_PDU02_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TCM_025ms_PDU02_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrCrpMdA_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrEPBAppReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrEngdStaV_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrEngdSta_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrEstdGearV_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrEstdGear_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrIntnlSwPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrIntnlSwPosV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrPrkPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrPrkSysF</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrShftLvrPosV_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrShftLvrPos_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrShftPtrnASts_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrTapUpTapDwnMdSts_TCM</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/TrTrgtShftLvrPos</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.025</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342caa00">
                  <SHORT-NAME>TCM_025ms_PDU02_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342cc500">
                  <SHORT-NAME>TCM_025ms_PDU02_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342ce000">
                  <SHORT-NAME>AutocTrCmddGear_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrCmddGear_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d1600">
                  <SHORT-NAME>DrvrShftCtrlTrgtGear_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlTrgtGear_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d4c00">
                  <SHORT-NAME>TrEPBAppReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEPBAppReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342cfb00">
                  <SHORT-NAME>DrvrShftCtrlReqDndIO</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlReqDndIO</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e9000">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342c8f00">
                  <SHORT-NAME>TrShftLvrPos_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPos_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342c6000">
                  <SHORT-NAME>TrShftLvrPosV_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPosV_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e2400">
                  <SHORT-NAME>TrPrkSysF</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkSysF</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e0900">
                  <SHORT-NAME>TrPrkPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e7500">
                  <SHORT-NAME>TrTrgtShftLvrPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTrgtShftLvrPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342db800">
                  <SHORT-NAME>TrEstdGear_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGear_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e5a00">
                  <SHORT-NAME>TrTapUpTapDwnMdSts_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTapUpTapDwnMdSts_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342e3f00">
                  <SHORT-NAME>TrShftPtrnASts_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftPtrnASts_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d9d00">
                  <SHORT-NAME>TrEstdGearV_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGearV_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d3100">
                  <SHORT-NAME>TrCrpMdA_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrpMdA_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342eab00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d8200">
                  <SHORT-NAME>TrEngdSta_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdSta_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342d6700">
                  <SHORT-NAME>TrEngdStaV_TCM</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdStaV_TCM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342dd300">
                  <SHORT-NAME>TrIntnlSwPos</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPos</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342dee00">
                  <SHORT-NAME>TrIntnlSwPosV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPosV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342ec600">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b342c4exOa505a3f19f25843c4b342c7c00">
                  <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_025ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="N200000119f4464397e360d9XN200000119f4464397e360d300">
              <SHORT-NAME>TCM_025ms_PDU05</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU05/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.025</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b0400">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b3300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159bb500">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqRespTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159bcf00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqIntrvnTyp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159be900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b9b00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqReqVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b6700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGear</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b4d00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_Reserve01</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b8100">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGearV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e360d9xN200000119f58e5e90159b1f00">
                  <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_PTCAN_FrP05</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="N200000119f4464397e36069XN200000119f4464397e3606300">
              <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TCM_025ms_PDU20/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.025</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c0d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c3c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c8a00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve03</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159cbe00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrACCToqReqResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c5600">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve01</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c7000">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve02</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159ca400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve04</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e36069xN200000119f58e5e90159c2800">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITCM_025ms_PDU20</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b337ff7XOa505a3f19f25843c4b337ff600">
              <SHORT-NAME>TC_IMCU_50ms_PDU28</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TC_IMCU_50ms_PDU28/EDUOilPmpMotEnb</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TC_IMCU_50ms_PDU28/EDUOilPmpMotSpdReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TC_IMCU_50ms_PDU28/EDUOilTem</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TC_IMCU_50ms_PDU28/EDUOilTemV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b337ff7xOa505a3f19f25843c4b33802200">
                  <SHORT-NAME>EDUOilPmpMotSpdReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilPmpMotSpdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>5</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b337ff7xOa505a3f19f25843c4b33800600">
                  <SHORT-NAME>EDUOilPmpMotEnb</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilPmpMotEnb</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>6</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b337ff7xOa505a3f19f25843c4b33805800">
                  <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b337ff7xOa505a3f19f25843c4b33803d00">
                  <SHORT-NAME>EDUOilTem</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEDUOilTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b31eabcXOa505a3f19f25843c4b31eabb00">
              <SHORT-NAME>TDM_200ms_PDU01</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TDM_200ms_PDU01/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.2</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec2600">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec4100">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec5c00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved15</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb9f00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtOn_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb3300">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIndLghtF_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb6900">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIndLghtF_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eace00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtF_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ebba00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtF_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb8400">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtF_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec0b00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSideLghtSts_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ebf000">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrlrCnctSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec7700">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved27</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb1800">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIO_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eb4e00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIO_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eafd00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtOn_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ebd500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtOn_TDM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ec9200">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved39</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ecad00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved47</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ecc800">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved55</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ece300">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ecfe00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved71</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ed1900">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved79</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ed3400">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved87</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ed4f00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved95</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ed6a00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved103</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31ed8500">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved111</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eda000">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved119</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31edbb00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved127</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b31eabcxOa505a3f19f25843c4b31eaea00">
                  <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITDM_200ms_Group01</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b322327XOa505a3f19f25843c4b32232600">
              <SHORT-NAME>TPMS_400ms_PDU06</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/TPMS_400ms_PDU06/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.4</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b3223a300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSSnsrRdoFrqcCtr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b32235200">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSSnsrID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b3223be00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSSnsrRdoFrqcCtrLoctn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b32236d00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSSnsrIDLoctn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b32233600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSBtmNosRSSI</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b322327xOa505a3f19f25843c4b32238800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSSnsrRSSI</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32c90cXOa505a3f19f25843c4b32c90b00">
              <SHORT-NAME>Teter_ECM_10ms_PDU20</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/Teter_ECM_10ms_PDU20/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c90cxOa505a3f19f25843c4b32c91e00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEn12VoltStrMotCmddOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33157aXOa505a3f19f25843c4b33157900">
              <SHORT-NAME>ZXD_100ms_PDU76</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ZXD_100ms_PDU76/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33157axOa505a3f19f25843c4b33158c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpedRegulaModSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="N200000119f4464397e2fa0dXN200000119f4464397e2fa0700">
              <SHORT-NAME>ZXD_100ms_PDU77</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ZXD_100ms_PDU77/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ZXD_100ms_PDU77/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e2fa0dxN200000119f4464397e2fa7800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMSwReq_Reserve17</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="N200000119f4464397e2fa0dxN200000119f4464397e2fa5d00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMSwReq_Reserve16</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <N-PDU UUID="Oa505a3f19f25843c4b360119XOa505a3f19f25843c4b36011800">
              <SHORT-NAME>Diag_BKPCANFD_FuncReq</SHORT-NAME>
              <LENGTH>64</LENGTH>
            </N-PDU>
            <N-PDU UUID="Oa505a3f19f25843c4b360153XOa505a3f19f25843c4b36015200">
              <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD</SHORT-NAME>
              <LENGTH>64</LENGTH>
            </N-PDU>
            <N-PDU UUID="Oa505a3f19f25843c4b360166XOa505a3f19f25843c4b36016500">
              <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD</SHORT-NAME>
              <LENGTH>64</LENGTH>
            </N-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b074XOa505a3f19f25843c4b35b07300">
              <SHORT-NAME>NmPDU_BKPCANFD_FDR</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b14100">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b15c00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b0d500">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b12600">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b19200">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b0ba00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b17700">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b08300">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b09f00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b10b00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b074xOa505a3f19f25843c4b35b0f000">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b696XOa505a3f19f25843c4b35b69500">
              <SHORT-NAME>NmPDU_BKPCANFD_IMM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b6c100">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b79900">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b6dc00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b6a500">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b72d00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b77e00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b7b400">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b6f700">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b76300">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b74800">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b696xOa505a3f19f25843c4b35b71200">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35af3aXOa505a3f19f25843c4b35af3900">
              <SHORT-NAME>NmPDU_BKPCANFD_IPD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35b05800">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35af8000">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35afec00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35af4900">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35b00700">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35af9b00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35b03d00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35af6500">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35b02200">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35afd100">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35af3axOa505a3f19f25843c4b35afb600">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b1aeXOa505a3f19f25843c4b35b1ad00">
              <SHORT-NAME>NmPDU_BKPCANFD_LFSDA</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b1f400">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b2b100">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b20f00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b2cc00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b1bd00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b26000">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b24500">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b1d900">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b22a00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b27b00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b1aexOa505a3f19f25843c4b35b29600">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILFSDA_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b2e8XOa505a3f19f25843c4b35b2e700">
              <SHORT-NAME>NmPDU_BKPCANFD_LHRDA</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b2f700">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b40600">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b3d000">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b3eb00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b34900">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b36400">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b32e00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b39a00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b37f00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b31300">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b2e8xOa505a3f19f25843c4b35b3b500">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDA_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b422XOa505a3f19f25843c4b35b42100">
              <SHORT-NAME>NmPDU_BKPCANFD_RFSDA</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b46800">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b50a00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b4b900">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b48300">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b49e00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b54000">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b43100">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b4d400">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b4ef00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b52500">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b422xOa505a3f19f25843c4b35b44d00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35b55cXOa505a3f19f25843c4b35b55b00">
              <SHORT-NAME>NmPDU_BKPCANFD_RHRDA</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b5bd00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b56b00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b5a200">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b67a00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b58700">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b62900">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b5d800">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b64400">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b65f00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b60e00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35b55cxOa505a3f19f25843c4b35b5f300">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35adffXOa505a3f19f25843c4b35adfe00">
              <SHORT-NAME>NmPDU_BKPCANFD_ZXD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35aee800">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae0f00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae9700">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae4600">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoNOS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35aeb200">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35af1e00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOStoRMS_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae2b00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35aecd00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMSSta_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae7c00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NWI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35ae6100">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NOI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35adffxOa505a3f19f25843c4b35af0300">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NKI_BKPCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b359901XOa505a3f19f25843c4b35990000">
              <SHORT-NAME>NmPDU_CHCANFD_EPS</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35997e00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35992d00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b3599b400">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b3599cf00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b3599ea00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35996300">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35991100">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b359a0500">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b359a2000">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NWI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35999900">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NOI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359901xOa505a3f19f25843c4b35994800">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_NKI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b359a3cXOa505a3f19f25843c4b359a3b00">
              <SHORT-NAME>NmPDU_CHCANFD_IBS</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359b3f00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359b0900">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359aee00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359a4b00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359b2400">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359a8200">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359a6700">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359a9d00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359ab800">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NWI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359ad300">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NOI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359a3cxOa505a3f19f25843c4b359b5a00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NKI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b359cb0XOa505a3f19f25843c4b359caf00">
              <SHORT-NAME>NmPDU_CHCANFD_IPD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d2c00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359db300">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d4700">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d7d00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359cdb00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d1100">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359cbf00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d6200">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359d9800">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359cf600">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359cb0xOa505a3f19f25843c4b359dce00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b359deaXOa505a3f19f25843c4b359de900">
              <SHORT-NAME>NmPDU_CHCANFD_RZCU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e6600">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359ed200">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e9c00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359eb700">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e3000">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359eed00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359f0800">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e4b00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359df900">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NWI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e8100">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NOI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359deaxOa505a3f19f25843c4b359e1500">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NKI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b359b76XOa505a3f19f25843c4b359b7500">
              <SHORT-NAME>NmPDU_CHCANFD_ZXD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359bf200">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_BSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359bd700">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_PBSMtoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c7900">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c5e00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoNOS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359b8500">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c4300">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOStoRMS_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359ba100">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c2800">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMSSta_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359bbc00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NWI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c0d00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NOI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b359b76xOa505a3f19f25843c4b359c9400">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NKI_CHCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a2eaXOa505a3f19f25843c4b35a2e900">
              <SHORT-NAME>NmPDU_PTCANFD_CCU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a38100">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a31500">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a33000">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a2f900">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a3ed00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a3b700">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a36600">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a3d200">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a34b00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a39c00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a2eaxOa505a3f19f25843c4b35a40800">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a1afXOa505a3f19f25843c4b35a1ae00">
              <SHORT-NAME>NmPDU_PTCANFD_ESS</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a29800">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a1f600">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a24700">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a26200">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a2ce00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a1bf00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a27d00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a2b300">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a1db00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a21100">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a1afxOa505a3f19f25843c4b35a22c00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a55eXOa505a3f19f25843c4b35a55d00">
              <SHORT-NAME>NmPDU_PTCANFD_IPD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a5da00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a66100">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a62b00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a67c00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a56d00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a58900">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a5bf00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a64600">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a61000">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a5f500">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a55exOa505a3f19f25843c4b35a5a400">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35acbaXOa505a3f19f25843c4b35acb900">
              <SHORT-NAME>NmPDU_PTCANFD_LVBM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ace500">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad3600">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ada200">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad5100">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35adbd00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad8700">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad1b00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35add800">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad6c00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35ad0000">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35acbaxOa505a3f19f25843c4b35acc900">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a698XOa505a3f19f25843c4b35a69700">
              <SHORT-NAME>NmPDU_PTCANFD_MMCU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a6f900">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a6de00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a74a00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a78000">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a72f00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a79b00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a6c300">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a71400">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a7b600">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a76500">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a698xOa505a3f19f25843c4b35a6a700">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCU_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35ab80XOa505a3f19f25843c4b35ab7f00">
              <SHORT-NAME>NmPDU_PTCANFD_PEU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ab8f00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac9e00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac8300">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac6800">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac4d00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac1700">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35abab00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35ac3200">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35abfc00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35abc600">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ab80xOa505a3f19f25843c4b35abe100">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a7d2XOa505a3f19f25843c4b35a7d100">
              <SHORT-NAME>NmPDU_PTCANFD_PICM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a8ba00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a83300">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a88400">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a8d500">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a81800">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a7fd00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a89f00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a7e100">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a86900">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a8f000">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a7d2xOa505a3f19f25843c4b35a84e00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a90cXOa505a3f19f25843c4b35a90b00">
              <SHORT-NAME>NmPDU_PTCANFD_RZCU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a9f400">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a9a300">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a9d900">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35aa2a00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a96d00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a95200">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a98800">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35aa0f00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a91b00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a9be00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a90cxOa505a3f19f25843c4b35a93700">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35aa46XOa505a3f19f25843c4b35aa4500">
              <SHORT-NAME>NmPDU_PTCANFD_SAC</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aa5500">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35ab2e00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aa7100">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aadd00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35ab4900">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35ab6400">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aaa700">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aa8c00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aac200">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35ab1300">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35aa46xOa505a3f19f25843c4b35aaf800">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35a424XOa505a3f19f25843c4b35a42300">
              <SHORT-NAME>NmPDU_PTCANFD_ZXD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a4bb00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_BSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a54200">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_PBSMtoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a48500">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a52700">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoNOS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a44f00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RSStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a4a000">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOStoRMS_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a4d600">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_NOSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a46a00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NM_RMSSta_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a50c00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NWI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a4f100">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NOI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35a424xOa505a3f19f25843c4b35a43300">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IZXD_NKI_PTCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35ce13XOa505a3f19f25843c4b35ce1200">
              <SHORT-NAME>NmPDU_SFCANFD_IBS</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ce7500">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35cec600">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ce2300">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35cf3200">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35cefc00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ce9000">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35cee100">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ce3f00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ceab00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35ce5a00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35ce13xOa505a3f19f25843c4b35cf1700">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35cf4eXOa505a3f19f25843c4b35cf4d00">
              <SHORT-NAME>NmPDU_SFCANFD_IPD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35d06c00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35d01b00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35d00000">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cf9400">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cfaf00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cfca00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cfe500">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cf7900">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35d05100">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35d03600">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35cf4exOa505a3f19f25843c4b35cf5d00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35d436XOa505a3f19f25843c4b35d43500">
              <SHORT-NAME>NmPDU_SFCANFD_PEU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d46100">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d4b200">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d51e00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d4cd00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d53900">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d47c00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d49700">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d4e800">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d50300">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d55400">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d436xOa505a3f19f25843c4b35d44500">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35d088XOa505a3f19f25843c4b35d08700">
              <SHORT-NAME>NmPDU_SFCANFD_PICM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d11f00">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d09700">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d15500">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d0ce00">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d1a600">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d13a00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d18b00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d10400">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d0e900">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d0b300">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d088xOa505a3f19f25843c4b35d17000">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICM_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35d1c2XOa505a3f19f25843c4b35d1c100">
              <SHORT-NAME>NmPDU_SFCANFD_RZCU</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d2c500">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d25900">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d20800">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d2e000">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d23e00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d2aa00">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d27400">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d22300">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d1ed00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d28f00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d1c2xOa505a3f19f25843c4b35d1d100">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35d2fcXOa505a3f19f25843c4b35d2fb00">
              <SHORT-NAME>NmPDU_SFCANFD_SDM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d3ff00">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d35d00">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d3ae00">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d41a00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d39300">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d32700">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d3e400">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d34200">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d37800">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d3c900">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d2fcxOa505a3f19f25843c4b35d30b00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <NM-PDU UUID="Oa505a3f19f25843c4b35d570XOa505a3f19f25843c4b35d56f00">
              <SHORT-NAME>NmPDU_SFCANFD_TDM</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-SIGNAL-TO-I-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d62200">
                  <SHORT-NAME>X_0_6</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d65800">
                  <SHORT-NAME>X_0_8</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d60700">
                  <SHORT-NAME>X_0_5</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d67300">
                  <SHORT-NAME>X_0_9</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d5ec00">
                  <SHORT-NAME>X_0_4</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d5d100">
                  <SHORT-NAME>X_0_3</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d59b00">
                  <SHORT-NAME>X_0_1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d68e00">
                  <SHORT-NAME>X_0_10</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d57f00">
                  <SHORT-NAME>X_0_</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NWI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d5b600">
                  <SHORT-NAME>X_0_2</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NOI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b35d570xOa505a3f19f25843c4b35d63d00">
                  <SHORT-NAME>X_0_7</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_NKI_SFCANFD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-I-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </NM-PDU>
            <SECURED-I-PDU UUID="Oa505a3f19f25843c4b3593b5XOa505a3f19f25843c4b3593b400">
              <SHORT-NAME>SecuredIPdu_ICC_SecOC_SyncMsg</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <AUTHENTICATION-PROPS-REF DEST="SECURE-COMMUNICATION-AUTHENTICATION-PROPS">/Communication/Security/Security_Configuration_Package/Profile01_Auth_SyncMsg</AUTHENTICATION-PROPS-REF>
              <FRESHNESS-PROPS-REF DEST="SECURE-COMMUNICATION-FRESHNESS-PROPS">/Communication/Security/Security_Configuration_Package/Profile01_FV_SyncMsg</FRESHNESS-PROPS-REF>
              <PAYLOAD-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ICBVC_SecOC_SyncMsg</PAYLOAD-REF>
              <SECURE-COMMUNICATION-PROPS>
                <AUTHENTICATION-BUILD-ATTEMPTS>3</AUTHENTICATION-BUILD-ATTEMPTS>
                <AUTHENTICATION-RETRIES>3</AUTHENTICATION-RETRIES>
                <DATA-ID>1391</DATA-ID>
                <FRESHNESS-VALUE-ID>1391</FRESHNESS-VALUE-ID>
                <SECURED-AREA-LENGTH>5</SECURED-AREA-LENGTH>
                <SECURED-AREA-OFFSET>0</SECURED-AREA-OFFSET>
              </SECURE-COMMUNICATION-PROPS>
              <USE-SECURED-PDU-HEADER>NO-HEADER</USE-SECURED-PDU-HEADER>
            </SECURED-I-PDU>
            <SECURED-I-PDU UUID="N20000011a036646ff92481bXN20000011a036646ff92481a00">
              <SHORT-NAME>SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <AUTHENTICATION-PROPS-REF DEST="SECURE-COMMUNICATION-AUTHENTICATION-PROPS">/Communication/Security/Security_Configuration_Package/Profile01_Auth_SyncMsg</AUTHENTICATION-PROPS-REF>
              <FRESHNESS-PROPS-REF DEST="SECURE-COMMUNICATION-FRESHNESS-PROPS">/Communication/Security/Security_Configuration_Package/Profile01_FV_SyncMsg</FRESHNESS-PROPS-REF>
              <PAYLOAD-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_SecOC_SyncMsg1</PAYLOAD-REF>
              <SECURE-COMMUNICATION-PROPS>
                <AUTHENTICATION-BUILD-ATTEMPTS>3</AUTHENTICATION-BUILD-ATTEMPTS>
                <AUTHENTICATION-RETRIES>3</AUTHENTICATION-RETRIES>
                <DATA-ID>1391</DATA-ID>
                <FRESHNESS-VALUE-ID>1391</FRESHNESS-VALUE-ID>
                <SECURED-AREA-LENGTH>5</SECURED-AREA-LENGTH>
                <SECURED-AREA-OFFSET>0</SECURED-AREA-OFFSET>
              </SECURE-COMMUNICATION-PROPS>
              <USE-SECURED-PDU-HEADER>NO-HEADER</USE-SECURED-PDU-HEADER>
            </SECURED-I-PDU>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="b64c0c40b20730948b2680b3f0cfe4f9">
          <SHORT-NAME>Security</SHORT-NAME>
          <ELEMENTS>
            <SECURE-COMMUNICATION-PROPS-SET UUID="Oa505a3f19f25843c4b3f74fdXOa505a3f19f25843c4b3f74fc00">
              <SHORT-NAME>Security_Configuration_Package</SHORT-NAME>
              <AUTHENTICATION-PROPSS>
                <SECURE-COMMUNICATION-AUTHENTICATION-PROPS UUID="Oa505a3f19f25843c4b3f7536XOa505a3f19f25843c4b3f753500">
                  <SHORT-NAME>Profile01_Auth_SyncMsg</SHORT-NAME>
                  <CATEGORY>Profile_SyncMsg</CATEGORY>
                  <AUTH-ALGORITHM>CMAC/SM4</AUTH-ALGORITHM>
                  <AUTH-INFO-TX-LENGTH>24</AUTH-INFO-TX-LENGTH>
                </SECURE-COMMUNICATION-AUTHENTICATION-PROPS>
              </AUTHENTICATION-PROPSS>
              <FRESHNESS-PROPSS>
                <SECURE-COMMUNICATION-FRESHNESS-PROPS UUID="Oa505a3f19f25843c4b3f755dXOa505a3f19f25843c4b3f755c00">
                  <SHORT-NAME>Profile01_FV_SyncMsg</SHORT-NAME>
                  <CATEGORY>Profile_SyncMsg</CATEGORY>
                  <FRESHNESS-VALUE-LENGTH>0</FRESHNESS-VALUE-LENGTH>
                  <FRESHNESS-VALUE-TX-LENGTH>0</FRESHNESS-VALUE-TX-LENGTH>
                </SECURE-COMMUNICATION-FRESHNESS-PROPS>
              </FRESHNESS-PROPSS>
            </SECURE-COMMUNICATION-PROPS-SET>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0248e1f7789d31e0b216dbb392afcebd">
          <SHORT-NAME>Signals</SHORT-NAME>
          <ELEMENTS>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e152cXOa505a3f19f25843c4b2e152b00">
              <SHORT-NAME>ICCU_100ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsValV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILStsV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4ba3b89dXOa505a3f19f25843c4ba3b89700">
              <SHORT-NAME>ICCU_100ms_Group07</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUActiveWkup</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrMaxChrgPwr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSpRsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptCrnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMDuty</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptCrnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptCrnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptCrnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrLastWkup</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrOtptVolV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrWkup</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrAltrCrntInptHVCrntLmt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOpngMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptVolVal</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group07</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b367556XOa505a3f19f25843c4b36755500">
              <SHORT-NAME>ICCU_100ms_Group11</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUClntFlowReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSktEleccLckEnable</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCClntPumpPWMReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCHdwrFlr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCIntnlFlr</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/CCU_100ms_Group11</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36887aXOa505a3f19f25843c4b36887900">
              <SHORT-NAME>IECM_010ms_Group00</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClOpenReqA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCCMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCtrlrRunCrkTrmlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnRunA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpReqToTr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnTestMdEnbReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIntlckRelayAuth</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtCrkAbotd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtRunAbotd</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_010ms_Group00</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b376b7fXOa505a3f19f25843c4b376b7e00">
              <SHORT-NAME>IECM_25ms_Group36</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrGearShftDircnF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvlnToqStabSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_25ms_Group36_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrkshftToqLdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCustSetngDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEnASSOvrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClStsV_ICE</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrInptClSts_ICE</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrMinVolReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrRngInhSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrWrnngDsp</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_25ms_Group36</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368901XOa505a3f19f25843c4b36890000">
              <SHORT-NAME>IECM_500ms_group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbs</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsOBD</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBarPrsAbsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_500ms_group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTemV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIntkAirTemV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnWarmUpCycAch</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdMsk</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemPtEstdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrClThrmlProtnNotfn_ECM</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_500ms_group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34147aXOa505a3f19f25843c4b34147900">
              <SHORT-NAME>IECM_ZONE_020ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_020ms_PDU03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_020ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFrngDet</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSFuelReqdOn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnASSStallDet</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnAutoSpNotProb</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqActuExtdRngV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqDrvrReqdExtdRngV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqRducnFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPropSysA</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_ZONE_020ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3415c2XOa505a3f19f25843c4b3415c100">
              <SHORT-NAME>IECM_ZONE_050ms_Group09</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_ZONE_050ms_Group09_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECODrvngSpdRutA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngAIO</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsGearShftIndSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEcoDrvngDspStsRcmndFwdGear</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMaxExtdRngV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnToqMinExtdRngV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ECM_ZONE_050ms_Group09</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e1bbeXOa505a3f19f25843c4b2e1bbd00">
              <SHORT-NAME>IEPS_010ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESReqTorRespV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAESStsInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCAngRespSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCCodrivingSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSVMCRespStsInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_010ms_Group03_Reserved3</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_010ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e1ba8XOa505a3f19f25843c4b2e1ba700">
              <SHORT-NAME>IEPS_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADASStrgDlvrdToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuPnonAngV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICHLKAHptResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAAngReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChLKAToqReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrStrgDlvrdToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSActRetMotToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCoDrivingSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSCurntDrvMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSDrvngMdCtrlInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSLimMotToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSPriyChnlFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMax</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMaxV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMin</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqValAldMinV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group01_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgCustSetngDspCmd</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e1bb3XOa505a3f19f25843c4b2e1bb200">
              <SHORT-NAME>IEPS_10ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IActuRoadWhlAngGrdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPkgAngReqRespInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAngRespStsInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltAvlLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAIPltCtrlChannel</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group02_Reserved2</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36735bXOa505a3f19f25843c4b36735a00">
              <SHORT-NAME>IEPS_10ms_Group05</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_10ms_Group05_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngGrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrCalSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrFlt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrInid</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngSnsrMultCapb</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlAngV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_10ms_Group05</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
