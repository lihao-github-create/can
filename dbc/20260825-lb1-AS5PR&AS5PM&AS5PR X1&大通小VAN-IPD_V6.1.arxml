                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcInfoSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87b24b33ddca3caf882521c54286fc5a">
                  <SHORT-NAME>TrfcJamRngNav_MComposition_TrfcJamRngNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcJamRngNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcJamRngNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f35be5dc9938369b991371ada8c6a7f0">
                  <SHORT-NAME>TrfcLghtFuctionSwReq_MComposition_TrfcLghtFuctionSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtFuctionSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtFuctionSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ffc79313267c35dba31a244410b6ce67">
                  <SHORT-NAME>TrfcLghtFuctionSwSts_MComposition_TrfcLghtFuctionSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtFuctionSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtFuctionSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d626280f88913012932833fc7853b783">
                  <SHORT-NAME>TrfcLghtStSp_MComposition_TrfcLghtStSp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtStSp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtStSp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c25714818123221a82873bc80f3b652">
                  <SHORT-NAME>TrfcMrgdForbidDist_MComposition_TrfcMrgdForbidDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdForbidDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdForbidDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3c16916d7f34325594e748a7b477adba">
                  <SHORT-NAME>TrfcMrgdForbidSign_MComposition_TrfcMrgdForbidSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdForbidSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdForbidSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1b9eab09d3703baf8e097be9db5451a2">
                  <SHORT-NAME>TrfcMrgdInfoSignDist_MComposition_TrfcMrgdInfoSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdInfoSignDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdInfoSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="972c18f1f9243921b4b5a10c9715957a">
                  <SHORT-NAME>TrfcMrgdInfoSign_MComposition_TrfcMrgdInfoSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdInfoSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdInfoSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3dacfbdc1c6b3303966095ebad57946b">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist_MComposition_TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdWrnngSignDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdWrnngSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bcb0e04c91023f1387df8f548ac993c5">
                  <SHORT-NAME>TrfcMrgdWrnngSign_MComposition_TrfcMrgdWrnngSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdWrnngSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdWrnngSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a10e8282b3b3daaaeb03ee9e6fed006">
                  <SHORT-NAME>TrgtCndSpdReqCamr_MComposition_TrgtCndSpdReqCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrgtCndSpdReqCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrgtCndSpdReqCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fdca1a23892031199ae91c4e2cd71930">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD_MComposition_TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrgtSpdSrcSts_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrgtSpdSrcSts_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e53938e667834f280efe9d268a767e4">
                  <SHORT-NAME>TripCntResetReq_MComposition_TripCntResetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TripCntResetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TripCntResetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="098d32fc283e3522897315fa8707c1b4">
                  <SHORT-NAME>TripCnt_MComposition_TripCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TripCnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TripCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b812180c7e7533afa3bed72b59bdc801">
                  <SHORT-NAME>VDCSlipCtrlSts_enum_MComposition_VDCSlipCtrlSts_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VDCSlipCtrlSts_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VDCSlipCtrlSts_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b6ccb732b9ec3e9491b2cb6c4691d314">
                  <SHORT-NAME>VehTiPblshDay_MComposition_VehTiPblshDay</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshDay</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshDay</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7bb7bf2c3d5e34fdb3d5c777fccc9839">
                  <SHORT-NAME>VehTiPblshHr_MComposition_VehTiPblshHr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshHr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshHr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cc0ab03fad5f3036bf6651cb536ef01e">
                  <SHORT-NAME>VehTiPblshMins_MComposition_VehTiPblshMins</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshMins</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshMins</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5aa63866494535d68f85abf3c4010fec">
                  <SHORT-NAME>VehTiPblshMth_MComposition_VehTiPblshMth</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshMth</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshMth</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a3a8594833f93a73867efb21c16cd4b7">
                  <SHORT-NAME>VehTiPblshSec_MComposition_VehTiPblshSec</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshSec</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshSec</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1eb269317c183ff19ea8428e535e394b">
                  <SHORT-NAME>VehTiPblshYear_MComposition_VehTiPblshYear</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshYear</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshYear</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="efd6f0ac491b38798f29577f814e3c64">
                  <SHORT-NAME>Veldownsigma_MComposition_Veldownsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Veldownsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Veldownsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="464fae5ff1c63c9a9ca838f00685a6c8">
                  <SHORT-NAME>Veleastsigma_MComposition_Veleastsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Veleastsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Veleastsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a1f2ec9fc9d4328e80a1a677f892b4ad">
                  <SHORT-NAME>Velnorthsigma_MComposition_Velnorthsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Velnorthsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Velnorthsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4e60c13b0ed737b1a8a6cefa21c7a024">
                  <SHORT-NAME>WhlRghRoadV_MComposition_WhlRghRoadV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/WhlRghRoadV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/WhlRghRoadV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48639a42d0bc329aacfb37b50babe295">
                  <SHORT-NAME>WhlRghRoad_MComposition_WhlRghRoad</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/WhlRghRoad</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/WhlRghRoad</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
              </CONNECTORS>
            </COMPOSITION-SW-COMPONENT-TYPE>
            <COMPOSITION-SW-COMPONENT-TYPE UUID="Na505a3f19f25843c4b1dae3XNa505a3f19f25843c4b1dae200">
              <SHORT-NAME>MComposition</SHORT-NAME>
              <PORTS>
                <P-PORT-PROTOTYPE UUID="114061858aba3b1fb0690a98ad69c889">
                  <SHORT-NAME>ACCConfmSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCConfmSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d9b17f7936c832738c4c9f135029e6b6">
                  <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCCurveSpdSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9e3a85a2403e3e40a68ca9b0fca001a9">
                  <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ea8222aecc3e3b6195a83c3ac19f98a4">
                  <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="14c3e13e27143b3bb5541e93896cd5f1">
                  <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d19d56f199bf35e4bf0ba823b8234f11">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a148966ece6f3ea381b6a8d4364e64ec">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01af1127297b39ef9c78526183acfd6b">
                  <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cc6d9a91b42237889edfec5bb40ba989">
                  <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3b4bff5567f2318cbd15e0710d93fb03">
                  <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d0d16d753eaa338a80427ad6556af883">
                  <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e82035eaaf3a3c75883ed286979ef63c">
                  <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="174af8eaf779332fad1effca0165a18a">
                  <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8f6a138874cb39db913c7e8300ed3bb5">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="89549dadc0df3e75a80e7226b92f8b4b">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9e7364f207fe39079dc129ded1e27ebb">
                  <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="67c6a047ecda35738477c7881af9be62">
                  <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="61d2eaf39a643161a3854062250478f9">
                  <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fa78eb8125383b42a557e0a7f30a0b0e">
                  <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eb85759603df3d61a26d2070e06be421">
                  <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ff1e76af5bfc34a4ae678916a23a9ecb">
                  <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d7f096b4313b3402b9669a684f38bfc0">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="84df0c8c203f345e8eb632a3bc621cbd">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9dfbef309d0d39b9a050b8c1a9f8675c">
                  <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d8a5e7912a3d396ab621b4b5df92a150">
                  <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8707afab4543331391dede8f96f70d69">
                  <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="55250e61a14534439ec055ca27764f86">
                  <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="52c8baab388931fbaa4f8108de70a026">
                  <SHORT-NAME>ACCDetObjHdngAng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjHdngAng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1fbae9ef802f31d1acd7196403e57186">
                  <SHORT-NAME>ACCDetObjId</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjId</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e6ee9eb2549d395c935b816c858e52bb">
                  <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0597770d7e933dc8959a890bcdea7a7d">
                  <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b0578922eb033e2685229f1fd71567d5">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b3d3471da7a53d06b6035867f1b44e2b">
                  <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjRisk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="311d5937464032bb9d5c31a088c2776f">
                  <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjSyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="05c54cf53e19340bba48dad7516c8abc">
                  <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjTyp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6dd477dff18430edaa744513c7202717">
                  <SHORT-NAME>ACCDrvrTkovReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDrvrTkovReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="650133cd9bb73c9594d0f4b1ba861db5">
                  <SHORT-NAME>ACCObjDet</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCObjDet</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="951848226a0d33c1b8da204dbfa63803">
                  <SHORT-NAME>ACCSpdLimtSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCSpdLimtSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8fa55b5477213001b6f2fcb80a752ce9">
                  <SHORT-NAME>ACCStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5056eb536f9938f4ab24a9da26000f96">
                  <SHORT-NAME>ACCStsSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3ced3c8225cc339e9b92db7b63aa15e7">
                  <SHORT-NAME>ACSFCatgrAStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrAStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0a87941bd405334da11e19a75d0e5533">
                  <SHORT-NAME>ACSFCatgrB1StsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrB1StsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="733ae138bb4b332e93984d05226ad740">
                  <SHORT-NAME>ACSFCatgrB2StsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrB2StsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f0eec420da243251b6619793a25614b8">
                  <SHORT-NAME>ACSFCatgrCStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrCStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0ca39a9aff5c37f9830941fd07aaa40b">
                  <SHORT-NAME>ACSFCatgrDStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrDStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9b223db61f693621b7e644b36fe51ca7">
                  <SHORT-NAME>ACSFCatgrEStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrEStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="58ae8db0561136cc9ca36e50acad6ea1">
                  <SHORT-NAME>ADAudioSWSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADAudioSWSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="03ff237d62623696bf2b73767f09eafb">
                  <SHORT-NAME>ADS_ISAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ffe9479d36b836189e01aa505f40fb8b">
                  <SHORT-NAME>ADS_ISASysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISASysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="aa650d028647330388eb70e26dfd9182">
                  <SHORT-NAME>ADS_ISASysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISASysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f750f74afdc93124a2d0acc08fa038cc">
                  <SHORT-NAME>AEBDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9dad46aa5db6341a8963874e54ec0591">
                  <SHORT-NAME>AEBMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e97e6bd30d713ada927b4a333cd1a095">
                  <SHORT-NAME>AEBStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a811ca44daea3bba86da3738a9098ef0">
                  <SHORT-NAME>AIParkngDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="aaba34936d4f392abc4a0e8e783710c5">
                  <SHORT-NAME>AIParkngEPAMdsts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngEPAMdsts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="58f94b4fcdeb3cb4b89de0d22b09e287">
                  <SHORT-NAME>AIParkngRespICB</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngRespICB</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="edae7794a3b43df0833c6d808c08becc">
                  <SHORT-NAME>AIParkngSSPLotSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSSPLotSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="889292c65f0b38d89cca09964e9baad8">
                  <SHORT-NAME>AIParkngSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4d6c43a315373999bf04c23ef8090ddc">
                  <SHORT-NAME>AIPilotIntervQuit</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIPilotIntervQuit</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="232ea50edfdd3d08879f0b16dbdbae12">
                  <SHORT-NAME>APAParkInOffsetType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAParkInOffsetType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3c2b9a7ea64d3cac85e19c787a485ab4">
                  <SHORT-NAME>APARemShifGear</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APARemShifGear</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="11122f6a4e043f619b67e45fe52d1a16">
                  <SHORT-NAME>APASW</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASW</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b91fe9eb35373d4f88569a29ac4b2bbd">
                  <SHORT-NAME>APASpdMdSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASpdMdSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8684f740bf533e01b08cf04718d5940b">
                  <SHORT-NAME>AutoMainBeamLghtReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoMainBeamLghtReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8698e052575d3c30b3f4461c15433777">
                  <SHORT-NAME>CCSpdVcCmdCnfm</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCSpdVcCmdCnfm</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="11e986dadbc43ff985500c10d39fee0e">
                  <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCSpdlVcCmdSwReqDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1ff75e8626423befb6a6de6e39654359">
                  <SHORT-NAME>CSFStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CSFStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eb59844538e336e6bd23ed92adf08ee2">
                  <SHORT-NAME>D2DPriETClanSwReqResps</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DPriETClanSwReqResps</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="48661c7d2baa399397a20a7e7c001f33">
                  <SHORT-NAME>D2DSwReqResps</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSwReqResps</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="989b4b4c5d303971ab3cadfaba7b15fa">
                  <SHORT-NAME>D2DSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="999919bd80da3923a26ec59c9828781e">
                  <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DTCInfomationIPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="198e11ee96523a04afab5701e5dacc82">
                  <SHORT-NAME>DetourMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DetourMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="50eca6a9af993d818b5573733348becf">
                  <SHORT-NAME>DistSinceTrgtCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DistSinceTrgtCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c74bae1563c353899b8ccb977f778c7">
                  <SHORT-NAME>ELKDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1a9e3f6b08103cc986a980b2ff2e61e3">
                  <SHORT-NAME>ELKSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fa2d48d153d63f77b4781c22f74fa8ec">
                  <SHORT-NAME>ELKWarning</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKWarning</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c019d463bb63cf89877e5fc177ce1e9">
                  <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EORWarningEvtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f72b6bf28c6536578abdd104bd1ac496">
                  <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESFStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4778a03610453ee2b0b9601a614adf2a">
                  <SHORT-NAME>ESSAdoWrnngDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSAdoWrnngDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3df11133cc963838a9bf3c4609c60079">
                  <SHORT-NAME>ESSDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e730d01bf74a314c9e8b64bb8c57fb3c">
                  <SHORT-NAME>EvtPotclSigIPD1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2ad1e735415136aa83ffea531c5e420e">
                  <SHORT-NAME>EvtPotclSigIPD2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dcf6687c1ccd3319bb39de98819a4420">
                  <SHORT-NAME>EvtPotclSigIPD3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6eb9ef45d6d233c1b3f6913ca4134fb0">
                  <SHORT-NAME>EvtPotclSigIPD4</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD4</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5cbc1f7c369a38b5bcbaf436c2312aa2">
                  <SHORT-NAME>EvtPotclSigIPD5</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD5</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2f68781590463599996e8dc7be5b3261">
                  <SHORT-NAME>EvtPotclSigIPD6</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD6</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a697a88dc0623b06899ea3c82eeb5d2c">
                  <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD7</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="afcdb0c3172c38e8bf347e5bd420d20f">
                  <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD8</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6e1dcb0383293086a860a55a2265352d">
                  <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="404aaeb2c1f63104935bc7ab2ea6ebc1">
                  <SHORT-NAME>FCTSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f7080d8f970b3452aece40069fa75bb8">
                  <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c441a1487de135818ad9214d531f6887">
                  <SHORT-NAME>FCWDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dbc0adafc3b038b99dcd5aa01125b7ba">
                  <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="54fbb9de399530c98032ff000b2c89d5">
                  <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e80f5a25f1d130cbadf0bd2956a639ba">
                  <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWrnngSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4e6ffc355c5035c5ac55bfcedf363d48">
                  <SHORT-NAME>FLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6921ceeeeef13cfcb3eeea516e87ea72">
                  <SHORT-NAME>FLSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dd75560a943e38f7a8eebaf3a84e4c6c">
                  <SHORT-NAME>FLSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="33dce1c7e49b3c4db0cdc03e79bb053d">
                  <SHORT-NAME>FLSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01bb62b6bb4d3b5996684eb294257b30">
                  <SHORT-NAME>FLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3eee601cf09b3c0ea50d27af5c88b12f">
                  <SHORT-NAME>FMLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e4f76ad506a73bd4be0f6172d8da188b">
                  <SHORT-NAME>FMRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d0768d1825363945971c9acbb1083853">
                  <SHORT-NAME>FRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="379670cedba231e9a7f4c5001355a1ca">
                  <SHORT-NAME>FRSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="45febffc14e7324b90026233043154fe">
                  <SHORT-NAME>FRSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5d8800b757bc3dd69fd7c333a1b85510">
                  <SHORT-NAME>FRSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2a62b2bf83b13ba78989eb32556c2f17">
                  <SHORT-NAME>FRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e68e2dd91f0e30ef89c30015540ab90d">
                  <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="42f76dcb716e3c30a1a8440701ba2d3e">
                  <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_20ms_Group02</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fecf50bd3629393b8c8dd09611d15bfb">
                  <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatCtrl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fa72c29b87203052b490c0bc52c70f33">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b3ebfe53b54c3665a9e56a62aeccba45">
                  <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="316f658ef88d3f75b949228687a56ed4">
                  <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a8f6c6187bab35519b05f85eea963873">
                  <SHORT-NAME>FrtObsDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="305a998f37ba3016a0046b58e37309f6">
                  <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="043672291e0535b78f3b5318e0def88d">
                  <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HORWarningEvtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f60a3b9db914382a8107a698c46bf778">
                  <SHORT-NAME>HPPFnSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPFnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="52a20e5473d73e4093653377c9533397">
                  <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPInBmtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="45248ac4506935f3b6a2e10348ec5092">
                  <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPMapBuildSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ddefef68cd1433debd66b903aaebd9bf">
                  <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPOnRoutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fbbfde0f7b9e320fbb8fa85a0c715219">
                  <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f834d3ee7b6d3d2894dc9b55d0b4f1db">
                  <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0999d4c9a6d4380d81ddd9c198297812">
                  <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="26394cd62524328ab10ad68ba95026e1">
                  <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group25</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="98b64e09648c3c83a51a1299c45f1526">
                  <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group37</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="28b53d94b7cd31d6ba1f1b8e6c25e573">
                  <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72d34e59c1013b25967cd2a193ac1272">
                  <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group05</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e20ffdf2e29e330482d4bf6095a24972">
                  <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group07</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="25342d47426a38179f065e1236c3ce09">
                  <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group09</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="035b72ee848832328015510c75ed3ea2">
                  <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group12</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7797acd06c74312ebce2fa20ee14327d">
                  <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c4d8ac72fae23a058801fe499c628e05">
                  <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group15</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ab35aeb72f7534259581bc6721e7cb6b">
                  <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group46</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4dcc5520378f3b13894e7ee001f18736">
                  <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group48</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d08f20e840cc34f9a84d1bd3920c4805">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_10ms_Group20</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4d3d46d5fecb39b99bd31a727890392b">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="695e3cbb5b91374189a32fd4aa4f2329">
                  <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAVCamrHeatReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="75b71948c8fa3ab49f470f9631a6a1e2">
                  <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAlgFlag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="92584367e2ff3e5d8edca76d98b444f8">
                  <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAurixTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="54e2d329acef3afc85c7298701a6565b">
                  <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDComKeyEnbResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2f2d08650aa2318981171c44b3606251">
                  <SHORT-NAME>IPDDataId</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDDataId</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="46333bfcd9cf3ccc934011b578db9e8c">
                  <SHORT-NAME>IPDErrorCount</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDErrorCount</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f608391c1b193422b8b4b4144fdb4b08">
                  <SHORT-NAME>IPDFailedReason</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDFailedReason</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9bfb5f176ec2399391295490c3faa238">
                  <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDIdentityResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b635f76e3e8b369591cf768f149ceaca">
                  <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDKeyStatus</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="42cf69521ed2376884fda590f313ee71">
                  <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDMCUTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5522bb087fa63980a779862cae47779b">
                  <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c4d484e3bcbf3f40848b2cf42655c7df">
                  <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0ffe317ecc743c939139ec722723e14b">
                  <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPMICTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f488936a8d3239ca80c188b5504ca287">
                  <SHORT-NAME>IPDResetCnt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDResetCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e7ee5fd85d873d10a542a44f84915431">
                  <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDSOCTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f3d61cd393d23ab3b459b3b0c130efed">
                  <SHORT-NAME>IPDStsResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDStsResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72c62454f9c63845b2e62584f5e50cf2">
                  <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDThermalWrnngLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8803def947023c6ab2b9ef987dfaddf6">
                  <SHORT-NAME>IPDTripCnt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="04857741a10a3d0fbdaf2d58693034e4">
                  <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCntResetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fab42757bbe236d7accc033c390d2b65">
                  <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripNvmTag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b605ef8302f03e8d8af42cf834e31be5">
                  <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltFlwReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="32c962a670e03a8683f6d8114e23d5f7">
                  <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltReqFlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b0ff32c3d0c836278dda1dc4722d8930">
                  <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltTimeReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="996a14fdf41a397bafae16f671d606dd">
                  <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group43</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="671aeb34823c38fcb6d33c5a9c9898a9">
                  <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group60</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e89609e3fdd230819d3c14500e617372">
                  <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group64</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72fd165d54ab3207be36926e21467c9b">
                  <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group67</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a64aab6d873b30049fefbfa158175b46">
                  <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group14</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="488c5d9a2fff3c228d5af5f5db944bdb">
                  <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group49</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="98d8ef48ebce3beab00564b7300c74fc">
                  <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bb76b5b822853252bd4429b430da2b6a">
                  <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="49ca8588f8243d5c8fc86fcad4712a35">
                  <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc57a1eda3ff352a8572c0396d55170c">
                  <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f3564ef9ca2d315ca5c91c840f5a6b52">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="41749b231f7c377d8ff93a5175a63ad0">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4bb5bfa5c6683982935b6db21ace48b7">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c6d4d371b8603d1c85828c7d080b8007">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dd1065d0701a31b79a9ad37e9f29d716">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f432add9883d30918731ea0fb0dbc4a1">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="66102d9bbfa3363a99f30079cf91a9f8">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6d5f02887d9232529824fe646adb4edc">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="73ef89fddad83414bdbce8f725e34d76">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="adcde9b4b0f23c5cb828b6abec82ea9b">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="91ae5da5746733b590a3aa7e10ca50fe">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f4c905681fd9385599b535277dcb5db2">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3e5931d88f2e39c797588af74f774f32">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="310cad21903e3bc0b07b0c57e5788ab7">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cccbb2bc6c4a33d0859b0175fe4780f9">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bbd820cd21a3389887362c7ea3e08971">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2b0817b36555310082c6c0fb82a5aea5">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="773e4acdfe8f3916a221bcdad3b0623e">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f9450d0b8d7436b59db68bdb8dab876f">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c8488d2a171537f78454dd00ac85b7f6">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9f3715ec1d383497b5d67ad53d7d5443">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="11164a8c26fe3624893737bcd24df52a">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="baf0dcaf7e2234c7b82f64f785ed6b80">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="84a3afe652f13ec49455c11ebfdd8709">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f2db6c42c35433cfb3c7312128ae05b3">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4daafdeb1e70309e87ee3c90503b4e25">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ebf04522a04f30f49c9b0505505d8180">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7a9a184209ef3a2a8099febe2625b046">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c5be8b5c14af3b81be623c2c22a426a6">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ce4548df071a34498239b5863ec8cf44">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="94f5cac9eac73bab9c267ce8566fe379">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f58e579db2a63bd7814406815ade62af">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4cc050974f3538cdbe268bc848dcb1df">
                  <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2795a9b5820f3f9ca44357f4d1d708f1">
                  <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d6d70836c79a324ab7e9cd7112bf81fa">
                  <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b6879a6a73a634d781f381f4018b433c">
                  <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="243dea3ac2e031ed8ffab94434440fbe">
                  <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="96ef68aff9bc33aebe840d8f2eea59bd">
                  <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2c439db8889235e6948b7354b2f62164">
                  <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="43263908d7203957a3975efa5f3d784f">
                  <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ba4f3b4e7e2632759d3c52ded616c990">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_Sporadic_TimeSync_Group</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="48ec3e9e130d355ab154954c7f785f20">
                  <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_VehLckCtrlReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ce90dbb6c10b32ce984f5d1fc57e6364">
                  <SHORT-NAME>JAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/JAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a79779b1301d31ba93a54df8b93f28a4">
                  <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSCurToEndPntDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9022d24c2fc13d9c8b062ff964d545eb">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSInfoDispReqToICM_HPP</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="012a98f607403f599bfcdc828bd02623">
                  <SHORT-NAME>LCRInHMI</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRInHMI</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5f89efc63a5c389499e1d45db647b762">
                  <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8242bc5892c93b98a54c808ed168f490">
                  <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e35cd00bde493680be26c925b120b52d">
                  <SHORT-NAME>LFCTWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ac4883867b5432f6a5c001f6b2f920be">
                  <SHORT-NAME>Lane0_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="60181641bde0310f81c91c3c23c77fcc">
                  <SHORT-NAME>Lane0_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="154bda8540d43e768e0e92e0e095dff0">
                  <SHORT-NAME>Lane0_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0939ad4359e43b0897fdfdb7950a2fcc">
                  <SHORT-NAME>Lane0_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="994d903b632c349b9332614871fa2992">
                  <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d32b0469f2ca3e2a96dacdc446b4ee8f">
                  <SHORT-NAME>Lane0_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eeef7232a8293016ae11ea6d417b82e0">
                  <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5f5e75045586347dad7c6da01507c946">
                  <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8aa8a971fec73381859529a080810cf8">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01e16bcc13c43f37b3cec62fb1f74fee">
                  <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8df04db3ccd930eb9362ef988339e938">
                  <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3826878f13f0354d8228665e0bb91b84">
                  <SHORT-NAME>Lane0_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b0e8de3887ea37e58290e03af6777621">
                  <SHORT-NAME>Lane1_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bd448899c75939b792c713ea937ba507">
                  <SHORT-NAME>Lane1_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="461b70b3f38c32dbbb757b4fe0cbe847">
                  <SHORT-NAME>Lane1_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f3c5bb3ba553373bbc29eb26382c61ec">
                  <SHORT-NAME>Lane1_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f775be9bcca6321d9d5f7b6fa4192ebe">
                  <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fa95ccb37adf32f3be5ea46c7d12a3c3">
                  <SHORT-NAME>Lane1_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="601389f561a2336fbaa06fc4ca228546">
                  <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d4cac90a75a13fddbec339fd990b56dc">
                  <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4ef9292eb2123101a7d41fa325562132">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a6931c27689a33e7ba31527775bf48a9">
                  <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b6ed4b3587543ec5b3a05a5c0b0ae5ce">
                  <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="144ad753fc603367afc70caccefd8ddd">
                  <SHORT-NAME>Lane1_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2a56d088ae883807b20becd8d27a5dad">
                  <SHORT-NAME>Lane2_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b850ee2af5893a6bb6d2326a872721e9">
                  <SHORT-NAME>Lane2_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="955afa8837983bb4b76f9ee81fc5726e">
                  <SHORT-NAME>Lane2_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1a7a98942a2635179a5792de90d7bb25">
                  <SHORT-NAME>Lane2_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4080bebae4c237a6ae196ed2b1036864">
                  <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a48f161d76653cffa9fc2942a9fd6dea">
                  <SHORT-NAME>Lane2_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c267581d35313333b23595c03d309abe">
                  <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c0ba20585683f01b0e75d95a7c9e64b">
                  <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c4decd800f1433c38b910554e42d3722">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0be7164ce9963cf6902db1f464664ed1">
                  <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3d3769ad97293e47b95c864ee8323a63">
                  <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="31aa3626853734ea84de1b12ec0e39c5">
                  <SHORT-NAME>Lane2_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="56630b0c764c30269c65ceb2aadcef2c">
                  <SHORT-NAME>Lane3_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a1d07342fd8a37e79deda8a344e3dda9">
                  <SHORT-NAME>Lane3_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ac0aec6a8301359db58574fffd0b0270">
                  <SHORT-NAME>Lane3_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="19bfe49f58433dd8a2206b89791d1748">
                  <SHORT-NAME>Lane3_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6d629366a84d3be39cd88e56b66a5ce3">
                  <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bd114764d89535d19ec78d436471985a">
                  <SHORT-NAME>Lane3_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="31e1ffbbab253ba185d72e30ecec8af8">
                  <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="922e36bbacb8332fb4319d006daa8d10">
                  <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="343a76ea288e33ab97f50459a0ad8319">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cd410f2435973e6caed178c4e4c82fda">
                  <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="455e0cc3cb0639e4a239c6f1961974b1">
                  <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3d0c18800c443daf9c4713f32f1a20a1">
                  <SHORT-NAME>Lane3_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0fa6cd5909c938a2938ddadece82dae0">
                  <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemParkngBtnRcnm</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9bf1b1606e7434f78954fe7379189496">
                  <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOACitySysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="341ca5dd65933abfa04ed76f89fc7c96">
                  <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOADistDecMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3059d798c6cd3cde82cd0fdaddb64448">
                  <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="94eb94f8f8b63757b9332a1b21b84a90">
                  <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f7a2d77d428a30ceae55fa4b5bf321b5">
                  <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bf456be5c45d3e5aa786cd414c48d973">
                  <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="97f7e2eb85ba3cd29686a03d43729b03">
                  <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fba6bc12daa2355a9fa167ace96cc713">
                  <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ebea545eb12e3e23add3d49f10ce14ea">
                  <SHORT-NAME>NOPSysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5eb300ec20553ee2a1302893b441b291">
                  <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="11cf791db0723e5db8c0ceacd620afbb">
                  <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadBackwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="412eee198d2e300a8e3b2bb11b578c1f">
                  <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadForwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c7fc093265493b3f94a031c9895da1b9">
                  <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstBtnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="91450440cce1305e9c1dcd40eea08fdf">
                  <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3df40e158da53501bb62df3beca1f447">
                  <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5bc3b944d6b8305b80a32e00ff8a0e5e">
                  <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="babec3be944539198b6ce363f3204bcd">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwDscmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c25267daace3f8c9140a33229747d9b">
                  <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssMesg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9f6ddc3a534633ee95b9a7785f636e68">
                  <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c6fa90b2638933a1a2916165c46a8286">
                  <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f125c7758649331e9f180bebfa4cc23c">
                  <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCndNotSt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="55c77bd1f20f3a7487222783b3386c45">
                  <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="21ac2fc5ec3b396f85ce76f3776b91c9">
                  <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDst360Req</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f2de9b5cb87630abb63309412a917749">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b9d504644d4e37cba04214fbc0be4db3">
                  <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="80e8ae6966f53cc1944969adf72d14be">
                  <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d2c31ccbd6c8373191a4918c9157de2e">
                  <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstTostDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3cdc16ecabd53c829624396804a329a6">
                  <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReDst</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="343f39a0226430c9a5f60152ca79ce72">
                  <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="905e5a839166385686f439c7808265d5">
                  <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e83b3334f8453e33949e600e289df849">
                  <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0522163e69a73d9fad7c18f0bd589014">
                  <SHORT-NAME>PDCSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDCSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f2ac790ce3143848b3d6dfa6f89cf8d3">
                  <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDSysKeyPsAvlbl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f5d5d316d4ee35a88c4a3c4f203e60fb">
                  <SHORT-NAME>PEBSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="53c0fac4a15b38c892f952353ccc5f76">
                  <SHORT-NAME>PEBSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d993ca1b7ee038e7932a348ffc825d4c">
                  <SHORT-NAME>PEBWarngReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBWarngReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cf0d2d1a77883a64b13a4bb72379b78e">
                  <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a14d2b6142f0373e9b8f76835a86a9ac">
                  <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3133de9c4ea938c798c93c3f8a7802a8">
                  <SHORT-NAME>ParkngEndDis</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngEndDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b2c4bb2bc89330d782a8e552fd832115">
                  <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngInPrgs</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c295fca0dc6a3d7185aa772c11c82470">
                  <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngNCPAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="49b5d613c82e3432a02354b8dec156fb">
                  <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="891d2c5a180a3cd4bc8a5a6e5fe79e99">
                  <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="43e61186e276324580d60f0583c2bc42">
                  <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5156b1e402ed3859b92f0b08afeef595">
                  <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutDircnSelResult</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7baf810e71f430af97a547e867b7c26c">
                  <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a8331e77b414304fb978582a1d64fafb">
                  <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7a6c876330c639e9a8e6fc3d9ae05951">
                  <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="73e28699a0633e3aa12a840850077b4e">
                  <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f71cfce4a1c635f5b4b385766c023963">
                  <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFrtCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c393e25f2f283edba0e2a8fddd7474fd">
                  <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSlotFindSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5d8db360b80d3052bf3eae476f56a62c">
                  <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSpdSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6481adb8171631fc85fdca1fb83d7450">
                  <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysADASFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0392d890484b3f7daabc871b107fd1b8">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF1FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="66cf4654348f35729fc0ae838a014a6e">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF3FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e6dc4b50aded3dff888050a942f2d920">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72d728aded8e3f8e9610625fc430fd7e">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0a6ae273b46d38d0b2cc51df823818f8">
                  <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b35feacee2f337bc87290429112b490e">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6bc5b47c71d734e397cf563fcc8e95a1">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="24d8caaaefb038c08c7bc683530aadf7">
                  <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFDRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="995ecb34a3a13974ab5b5300172acd94">
                  <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFLIDARFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5e1946e9cad234fba9f667474633be08">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrFFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="da55c70adf6733f491b722edb5ec7990">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrLHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ae34987fb6d836f9bfa05272e0aa54a1">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3f8d004713ea3edc90f33ee931d42db7">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="74ff5cbc19363edb96602a44008b1517">
                  <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6398122a134d30e7b04c292ab8c3672f">
                  <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2bff89f8024b3df783c33dbadc87d954">
                  <SHORT-NAME>PilotSysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="de61f975e67d3451b1332eed32a8ac3a">
                  <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2fbe874555593639af52148eff24c38f">
                  <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b14429de10ad3fd298a70618e104836b">
                  <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysUSSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3cbd5170e88034149f64fb22f49b1b46">
                  <SHORT-NAME>PosALCFailed</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PosALCFailed</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="afbbd58f53b73401a014df827f253973">
                  <SHORT-NAME>PrvOutSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PrvOutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="57731035f75f33df957a80d95b5f8c6f">
                  <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RAAlrWorDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="86f3f3e300723925865e572e1312c0fc">
                  <SHORT-NAME>RADSSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RADSSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eadcabc5f751359aa7503ecec0be440a">
                  <SHORT-NAME>RASysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RASysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="64525a2041d8353ba442cba4d234bee4">
                  <SHORT-NAME>RFCTWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f496e9ecb53f36419600589ae834acc7">
                  <SHORT-NAME>RLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2665ac4a70e938198738962a71f716a2">
                  <SHORT-NAME>RLSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ffbbce335bec315eac6aa36837a3b0fd">
                  <SHORT-NAME>RLSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ea25763c2a6c3a20a97788c726f3a8d7">
                  <SHORT-NAME>RLSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ac2c614724bb3a959ac97a9a113c7d31">
                  <SHORT-NAME>RLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="33a3772f6f6b318da3e0adca5a20fcb8">
                  <SHORT-NAME>RMLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1482caadfc86358bbb9224f104104182">
                  <SHORT-NAME>RMRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e9a337ecfa573d8db95b5a1c055fa7f0">
                  <SHORT-NAME>RPShockDistL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="46b922f96ce93a1f91a716cb7ae600a7">
                  <SHORT-NAME>RPShockDistR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bcd013ac92753b6abc5dc6df888821b6">
                  <SHORT-NAME>RRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b46cefdf7bb53097b9fb28f4a845bcde">
                  <SHORT-NAME>RRSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3ba5afe3cc51365f9bffdce1dd3d2763">
                  <SHORT-NAME>RRSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="222ea20dd4473b1e8bcd7dc7272fb5db">
                  <SHORT-NAME>RRSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b311027df0e735c0baf090ee488378e7">
                  <SHORT-NAME>RRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="799be559681f366392895fc848e89c67">
                  <SHORT-NAME>RoadHeightL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4afe5b0bf7e531739128203611d834be">
                  <SHORT-NAME>RoadHeightR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="31868e9a114f305b882cf60d3e37ef71">
                  <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1ecf44940a0b3969b34933861d7fcec1">
                  <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4685953a7b8837d5a99c713229cdf2fb">
                  <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f76ef5557dfb30aaa56e8f8b27e0466d">
                  <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c3712c39e2dd3ccb8d8714a59ab8766d">
                  <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c8b4f07703873e6daa05d155feef49b3">
                  <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="744fb97e8f7f340293473b6386302cca">
                  <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a6caa08e3ba434cc8daa2a96d022076a">
                  <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ec61753fe0e53a2c98b2653d33c01362">
                  <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ae0ae4d6b819393898bb84c9f3bd6b43">
                  <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7f2c484de81535348b704a02cd04b70b">
                  <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b12b1fedd439394d96e8588a9648f3ae">
                  <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1785f85a9fa13a1ab363b8d3732b32bd">
                  <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="40b74f51929d32f18017de9aed2d610d">
                  <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bfb208c82c7f345b921850cef9370df2">
                  <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0efd6d1495ce339cabf9b51b00c027e9">
                  <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="89fb6255108238f0b4eedc8578d9b6b7">
                  <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3d1e97082d8033c3993818d4c457c624">
                  <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c9bc0b34c6fd3e68a88d0474e6489b57">
                  <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2883b58384b139d3be82c9552a604f07">
                  <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e395ce56b5d63cb4a3d31a61aaf6f18d">
                  <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="648c912bef653371b821c4819d373a28">
                  <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7874ab88c94436eaa1d1645d08bb5163">
                  <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bb4edd966625328eb8617aedbebd7be6">
                  <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="283425ffe52a385385c60704f703e4ae">
                  <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5960b22b9cb73a63b0660cb4e645f135">
                  <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="14f07ab696d83ae682c4d5e10ca5a842">
                  <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d7bc2167188c3c4489b3eb80c2d758bf">
                  <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9e00b8a7d3d03557b496b3227a01ffd7">
                  <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4363285665203aacaf41897f2928cf20">
                  <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a618cc5f3383f528c742746913ade19">
                  <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0c429dc5a73337f997cc4ee577787e09">
                  <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e2e96e2fc0a43faeac9bff1d2dc89ee5">
                  <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2e33c76ee13633a7a24c2a2c4a8a44d3">
                  <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0137fdb7bfa535b2a17acb7babd9b738">
                  <SHORT-NAME>RrObsDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0311eb732ffd3b3aafbfa4c9b42be9cc">
                  <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4c7cf67e2e4d3107a7f9e70a748e8e1a">
                  <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFAudWrnng_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3ce56cbf94813817ab9f3b775d7c5e2e">
                  <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2dee696f9616321b8a0b41e1e7f4b552">
                  <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4f4bbb468a893fd0b46b123214c0c5d9">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndResp_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="94099406bf193a19a6975f140bb5ca0e">
                  <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtInd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d3ad065aafc13004b4456f7240e191e8">
                  <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="34d0602d45e935af806f358435039036">
                  <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstCndStsCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="86e9b28954fc38fba122d0c3ed0c6089">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstSysTrgtSpd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="db463079c1fc3bc4980209958f2842b5">
                  <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLimitManualSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a04db9443cb83f57bc214c71a046b49c">
                  <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a4bcfc37d1443e3ba487436d93c0893f">
                  <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="34ecafcf0db93f999ff33fde669951ce">
                  <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="258d6f11a38c33eea1b93b896dcff03f">
                  <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2868792e2aa33740bfafb81d5534b149">
                  <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dc6525281ea437489fd2b3f3cc0bf141">
                  <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9762040fe5c13073916ece46d0200ba5">
                  <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TJAICAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8eea30e62a313baf90248aee08f67c93">
                  <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="83e455ff507332fb9e164c6ac565abb8">
                  <SHORT-NAME>TLRMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b5995bedc74a32cabc15f945a45c4e86">
                  <SHORT-NAME>TLRSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="017b96d493983910b5cd3a74e6ccfbd0">
                  <SHORT-NAME>TLRWarning</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRWarning</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a92b1d9a33136b9967b07ce0a9e401a">
                  <SHORT-NAME>TSRSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="43c9e2e9582a3306a094a6a87b69c6af">
                  <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReqResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72d2325d03f83b0da10c329b590ecaff">
                  <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtBanSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a402b38550753366afd2f333596195dd">
                  <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtWarnSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9f6c578c9d3a3ecea2890cff2db2f06a">
                  <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TgtParkingFavorite</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7bf445d1d9fa366fa233d5790de3f795">
                  <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ToEPSMsgChlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2d95b42bc0073a7084a0f0be9b724360">
                  <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfGreenLghtActn</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f230100f142936cda9f164a6bb56cbfb">
                  <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="21fd4a803f2730ed9ec6f7f3bd4887bd">
                  <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtStSp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d71d180f5f9f381b844e1e2b0b9953e7">
                  <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d7d1d543d35c3b16b316e32db45723c2">
                  <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1e05dadc884c35fda02b9ede930ee532">
                  <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f7ddafe6eca23cd782180c4433cf15dd">
                  <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4132428526bf3ee8bb5de7497a89fd73">
                  <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c08f4b9a2d653df285a094464eb69034">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9dcf7518ecee3fe99b1fde17d8c4b50a">
                  <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtCndSpdReqCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="186fb76cfb4d30e6b72c4d563976f846">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtSpdSrcSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="dac72b53c4483245bbefe1665debc356">
                  <SHORT-NAME>ACCConfmSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCConfmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="723e52f37a0b3e64a9ce29e02834d128">
                  <SHORT-NAME>ACCCurveSpdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCCurveSpdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f4183af128933e678b10e0ccb12dc023">
                  <SHORT-NAME>ACCSpdLimtSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f1a5bf836e223dfcb92c71e137382415">
                  <SHORT-NAME>ACCStsSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="180fa4ad5c5d350585ecdc912821f4cb">
                  <SHORT-NAME>ACCTJAMdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCTJAMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="342f8d80dfef3e77805561875995e021">
                  <SHORT-NAME>ADAudioSWReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADAudioSWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="97d059d9768a38d0bf0ae943e14377c6">
                  <SHORT-NAME>AEBSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0277a2f7220f31faa4a1bf162760f01e">
                  <SHORT-NAME>AIParkngEPAMdsw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngEPAMdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="825111b998dc3e62bb93ffcddabdd68f">
                  <SHORT-NAME>AIParkngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2bf184abec9f313a91505289b67945c8">
                  <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReqICB</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ce2ff9b6cedf3b8099f5d183210b5d70">
                  <SHORT-NAME>AIParkngReq_ZXD</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq_ZXD</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ff33d106da7a3d6c9633f317df11fb46">
                  <SHORT-NAME>AIParkngSSPLotSw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSSPLotSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2768a0decc6d340194d94abb58a8b910">
                  <SHORT-NAME>AIParkngSpcID</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpcID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8b9c165dec103083a64687ea440ba6ae">
                  <SHORT-NAME>AIParkngSpdsw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3af6df3252bd3dccb6124ff6184d8d2e">
                  <SHORT-NAME>APAOneKeyParkSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAOneKeyParkSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f472f2452643338f8bdef4ec2684b917">
                  <SHORT-NAME>APAParkInOffsetTypeReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAParkInOffsetTypeReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a3a9af3732ed3ba7bce917a8cf54344c">
                  <SHORT-NAME>APASWReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b64bac9833813333acf7a6afb7663b5f">
                  <SHORT-NAME>AVMDspReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMDspReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="25b066f018af36baa789f512b0cbf998">
                  <SHORT-NAME>AVMSt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMSt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3fc145d1bb773c819095b440efdd6bf6">
                  <SHORT-NAME>AVPMapRutMgIDtReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVPMapRutMgIDtReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c1109d2d6326323ea8f37d8c526cef73">
                  <SHORT-NAME>AutoLaneChngSetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="69c2a2a540a33f1ba6d3b97a564d479f">
                  <SHORT-NAME>AutoLaneChngSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7c17b4c09087309daac772f528dd25ac">
                  <SHORT-NAME>AutoLaneChngVcCmd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngVcCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="09f3c4cc3afc3b6cb602a7b6def77c9f">
                  <SHORT-NAME>AutoMainBeamLghtOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoMainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4a00dbef89823b73a670f4ae51c50381">
                  <SHORT-NAME>BSDSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BSDSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c0e9005d52ba38ad83a99644b1423c8f">
                  <SHORT-NAME>BaseLineLen</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BaseLineLen</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c94e39d9aecb3400984953228e2f0371">
                  <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CANprotocolinternalversion</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="623a830affd63f509c06462748599650">
                  <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d287af648bdb3bdd9dd15bac8fcbb6e9">
                  <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ccaab9761a413e88a05dcacbeaa19ae0">
                  <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c32ea2609a9b3659a340a64b4dad9365">
                  <SHORT-NAME>ChrgPwrReq_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgPwrReq_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ebf001fd9acc382e9a5ca078d1bafc4e">
                  <SHORT-NAME>ChrgReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c1c2144b96783b42abfb0f4660e75ab3">
                  <SHORT-NAME>ClstrDspdVehSpd_mph</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ClstrDspdVehSpd_mph</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e5212db0852d3e8c8d97355e7ecec6d0">
                  <SHORT-NAME>ComKeyEnbReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ComKeyEnbReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60548eaea9fd34adbb85d18709181e45">
                  <SHORT-NAME>D2DPriETClanSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DPriETClanSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ae9a5759904f3acb94e95e43864f498c">
                  <SHORT-NAME>D2DSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8dfa2c139f2033d19d061a8554ebf245">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_0</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="27738caea89434718930931fc0458012">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5a07184a96863fa0a313e02b5050c402">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b1a109061b96343480c93eb49339f366">
                  <SHORT-NAME>DMSCameraFps_IMM</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DMSCameraFps_IMM</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5e1e81291db933f690b9be2185b3204b">
                  <SHORT-NAME>DOWSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DOWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d4c3e7f7771c3cee935416edfb08628d">
                  <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DfstOnDspCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="db7ca93762df34eb971b62eb3bf4bcff">
                  <SHORT-NAME>DiffAgeInfo</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffAgeInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ae8a1d78fc713de58e5e68b0c393f8ed">
                  <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffDataLinkBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="911a2bb57b70317c9f23dd5c31ee34d4">
                  <SHORT-NAME>DircnIndLghtMdSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtMdSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7f97b902cf5c356fbfc5219bb475b863">
                  <SHORT-NAME>DircnIndLghtSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f2cbdf10e0653f508ee96a0b9a57f9aa">
                  <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DistToTrfcJamNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="71cbe3e2d9973deabc272f34bb7529ab">
                  <SHORT-NAME>DownVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DownVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="013bf8eaf8253d42b0b06e083d3d41db">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlFilt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8d92ca618cbf337bbc1232a92847c20c">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRawCap_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a407d7aa2db137eb9d2fb54cc3e0ca2c">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRaw_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5f971446766b339bbaf01e864a4518a3">
                  <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrDstrctnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ed9e6d8573c43862831f386accddffcc">
                  <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="326c878578163c79974aed9f2b95f261">
                  <SHORT-NAME>DsblICE_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblICE_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fdda20a1f2f43f13b6064cd738b6da35">
                  <SHORT-NAME>DsblISG_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblISG_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4b3afa97377f3550ab66c322aaecdb7c">
                  <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DschrgOptMaxPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a867a8a93cba3188986547c05e533f44">
                  <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_010ms_Group00</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="26488b29f9ef33dcb6c58c71c6494944">
                  <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_25ms_Group36</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0c7becf5aa0b3f2e8a2f61c95742f7bf">
                  <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_500ms_group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4683c717b2af3b47b2ffbc8c464ecef1">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_020ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0e34ddd381d93328bc07b4f512ca70e1">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_050ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="952b21a9697d391681b06b82899ecb1e">
                  <SHORT-NAME>EDUClntTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60d18f7a9e9134628190591a8cb46d97">
                  <SHORT-NAME>EDUClntTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d9f46c5f98d83062a1b5b6d7073d2027">
                  <SHORT-NAME>EDUOilTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b9960223aee934929419c07914ab57dd">
                  <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a332927b5e1932958740af7f5b27b178">
                  <SHORT-NAME>ELKSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="67f5779023183202b6e3ed5da749b534">
                  <SHORT-NAME>EPSAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5bbc73739ef2376798ab9526e32405ab">
                  <SHORT-NAME>EPSCTTX</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSCTTX</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e65f9ec13abe3a238c89b63b559abbfc">
                  <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_010ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="375d05b11c1e32a6aae54f792f0e2e67">
                  <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c069191d68d730988c67b638f7ba0eb7">
                  <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8fa2c449760032f786c7da008112d650">
                  <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ececc6d7de2239fdafd5152fe32d73ca">
                  <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="01ea7c9f8b7535818ef5a53b4642cb1a">
                  <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTClntPumpSta</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f6f1ea92141b334ebb9e181379bf6a54">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTElecWtrPumpActuSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="769806583b0c3bd589ef48f33e4336cf">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCBrkRgnPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ced25e4902e733458e71b00f71bf56c2">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="24deebf94c7c3fac967362c02d88a666">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9425136a8916350593ae252c7a22b070">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8d0ec50c7a633543a355d9a6111e101a">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3d66f2485d9639d799cbf6717f4e08d3">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCEmgcyPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="971d5f40e1a8379c84260fb0da8ad1ab">
                  <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCFCOReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="501f10e31808391d9bce3b72274ce6b4">
                  <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVAllwd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="db75abab75e030618e31455b4b513d65">
                  <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVHldReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1afa5fc7f764309882fa3f97a0e2be3d">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxChrgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="41593dfa30973f9d8bac92dbcd53360f">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxDschgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cd1e2039766c3eaf94342bb189442371">
                  <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESCLPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2df2ba1756d43625ae91a1a25b983746">
                  <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c17e1f7f423b30f99555ce0e0cec7e93">
                  <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESS_100ms_Group58</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b7ed495b96203c2588132dd816b93f8d">
                  <SHORT-NAME>ESSswReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSswReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e79aa2c621ae3503a04d71be6e2e17d2">
                  <SHORT-NAME>EVMd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EVMd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="92047be4d20136889e954548fbe7917b">
                  <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EastVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b24cd70c4bfd3f4db9cf278e808bcd65">
                  <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ElecPwrDistbnScene</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="edcf228f9e963d8b80fa096a9e4dab68">
                  <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/En12VoltStrMotCmddOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="531848d3c80830cc9a499080852e945e">
                  <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngBrkTqMax_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ca5b176c19df3a42a6c1d82edfa46e7d">
                  <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b0a4a1e942803c7e954c1d436903ce2a">
                  <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqTypReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fa5969c2c60534dfafe34c6c51d3b197">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqFstTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9a1e1ff2ab253b0fbc13ca62f93b1996">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqSlowTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3fbaa5e5e6133021b791dd2fd8e33200">
                  <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngPhsAng_deg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cedf4d485f9c3e94a599053a075c24cd">
                  <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSlowTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="da06a15d5b2735678d7a4a1e030d1bec">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSpdSafe4EngStrt_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="34edd724797237a5a9ed8a71e091dd66">
                  <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStallCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="49ac3a0208b438108c7e24db73819a5b">
                  <SHORT-NAME>EngStall_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStall_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e2315945b88b3d74b3b9954d026d0ea4">
                  <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStopReqCfmd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9e1c09e497d638daa779b586c68f9286">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtDampSlipFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7fa085645f0235f28e7b50aea1cd953e">
                  <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3159bd2f25d235969071f5786f8c15e1">
                  <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFail_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ee9d1b71c02032fb9967df929f050186">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtNoCapFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="82eac07bd6f33aea8408d7336489a1ac">
                  <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7fb3fc46c3c33bd7b33e06c42329ba23">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtStuckFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7c27d567bc8a3701a5c20520aff6bb45">
                  <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6f0a27f02d28333a85a09772fb45f99d">
                  <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f366bdf0cf91331892f649c19b8510f1">
                  <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0f53b045e28e3e69a4b5a8f7bddf6f10">
                  <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3928d8e7c5f13b299834e226520e1c06">
                  <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6a0294e05145365e80e87934f2607567">
                  <SHORT-NAME>FCWSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b8478fbd4d6f3d87a81a5e3581f35677">
                  <SHORT-NAME>FDRPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDRPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1cd4a4db950c3553abf1b2b6ee0daee4">
                  <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDR_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3d963537575e3f21b5343f89692bae5e">
                  <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3ff2b7eba2ad3c4ebd14852e849d83ed">
                  <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2d5360fa2d4436fba951e9ab68cb1685">
                  <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="737b12d8db093e7bac761d0fb8d8471e">
                  <SHORT-NAME>FLTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c9c010e3a7f137d69d1cb7b37070fe29">
                  <SHORT-NAME>FLTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d954957bbdc8344399eb8248171afebd">
                  <SHORT-NAME>FLTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9481d544fb1e36f18640283f24009454">
                  <SHORT-NAME>FLTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d518a1d52883c9ba38d273f241cd70d">
                  <SHORT-NAME>FLTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="559e852e27033063a9924a9efc1047ac">
                  <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLiDARPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5319b0c4bfef3c88b4d560310cefa3ff">
                  <SHORT-NAME>FOTAStatus</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="388e17da18503eb2833939e311f25048">
                  <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatusValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0345ab64227f3e62a25cdd1905515c3a">
                  <SHORT-NAME>FOTATarget</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATarget</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="22d3d0fff73f3212bb467a8d0900a0a5">
                  <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATargetValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="855b7dc8b3d53536bd5634323a05df4c">
                  <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d79fb494121c3b029aa787eca67a021b">
                  <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8b68975a93873a3cac450d8018d2bf06">
                  <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="babd7bb929523523ba9f9565ec6c188d">
                  <SHORT-NAME>FRTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="15c4ecdbfebb35ba8ee913e5ef8606b8">
                  <SHORT-NAME>FRTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bfe865e9d49f3e73bfd72260e9109f4e">
                  <SHORT-NAME>FRTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2ae4f7576fb634ee8d13ecf461435395">
                  <SHORT-NAME>FRTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="adee35c71fe53855b46ad9d817bc24ec">
                  <SHORT-NAME>FRTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ad61e131a0253d4994a5197a61e67d38">
                  <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="81977ab379353e7197f21c752ee0d257">
                  <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c86b8b3e6aab31ed8a8fad86eb6017a3">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPsngDoorOpenSts_LHZCU</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="57dc7d4aa93f3981b9c97fee9352c345">
                  <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a10c8511d0493964b1fd4f835761b77f">
                  <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSfcTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1506c7e29ba135ca983af09a2d3670f6">
                  <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndHmdty</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="420dd52c888a3b87882d88f03ee7877e">
                  <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b43ff9a9a8303a948c19c2bfb5bd7707">
                  <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="625b3aed4eb436f4842d66346b909a5d">
                  <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="afefced2ebba3019a76e49f053240dca">
                  <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FuCutReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="560132b948e03ca8b64d30fc6ae13935">
                  <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutDMFPrdtn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="388495041c4235b7be93f7915e15921b">
                  <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutEngStall_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="594d4b6001683b1db912c345c6b9af74">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutLosCommWthEMS_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b81e5d37e34139b98b60c6f4b76d3036">
                  <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b94a77af857c37918b3a2e62fb811fc9">
                  <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="99b2d07d297236d0868efabcd3732694">
                  <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HCUSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7457f1be865138609552bc14aebe7c51">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HmdtySnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7ab0405983653f95ae187a965f72ea9b">
                  <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="17b2dc7f365a34cfac70cf3e0a0cb4d3">
                  <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1dafe50f80833cce9e7c91f2401624c5">
                  <SHORT-NAME>IAMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c7153ffb01493834a6739acd951ff650">
                  <SHORT-NAME>IAMReststs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMReststs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9dda3070f88430b68e0875b59338c225">
                  <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="45eeda8746d73f079b72d495c571820c">
                  <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6305ae691ff2374aa0976e0facfc3731">
                  <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group56</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cdfa9a32ae0933ea8495df2ffffccb97">
                  <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_20ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e8d9d9e38b0b385aabe2a2e3759a132d">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="507e07c55ecd370ea1dca4903acd2158">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group34</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="869d7dc476be3d479b66848fe00afbf7">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group35</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0420880d70e630d9afdbc56747e16a8f">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group40</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="67e813e0fe5a3e278a3c1098d7e4e00e">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group57</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a0739c07089232faa44daede96935104">
                  <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_100ms_Group15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1b48eb454e173af2a2a7a0b50048bad1">
                  <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="33f9e8b4a86231719d7137ca8cade69c">
                  <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a579982c01d73a8b8484486720b8a7a7">
                  <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5e05edf53c63016a19fdba7d8bb3fb4">
                  <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="45cfeca312973a2c9842730364a5254f">
                  <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="106219c729273399a60d1132e6e7b734">
                  <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e22d54ed3af53242a608e742f85ab618">
                  <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="51c5df1581fb340982a48bdfd36d5137">
                  <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="86cff1c04abe3bd9bb8048272ca9eb92">
                  <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="936a99d1a1cb372bbb0a07e76423f216">
                  <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="30d7c9368c8133cf93e952fe2c72ef0c">
                  <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_CHAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f3e973359cf396ca97303187cd6045b">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_ZONE_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f36041ea2dea38a6bf41889205e614b0">
                  <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3b55c47517f131f3897f8530524bf685">
                  <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a7be6b8fee343cdd82fb0397fc66e01e">
                  <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group80</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7ebe9e45a4263206b91da4790edaae60">
                  <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_200ms_Group79</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0792effcf626385cbecc6d00d8a7d8eb">
                  <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c70a12b442cd3dd1b2c4c2a8841bc8cf">
                  <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6a92fc06687732399b7d0238b3e6d4ca">
                  <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6e63b924821d3bdbb23cf239343a716c">
                  <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group158</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="298f0c43108439939d1c3304873e3189">
                  <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group256</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c942d0cbd9db3cee98fb924309083375">
                  <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrDstcnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e97a467446aa353b8bf42b18c9b32387">
                  <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="93505546b75c3deab29b42896fa64b58">
                  <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="82c677eeb9ad3bd39dcfe29d709c4302">
                  <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMEyeOnRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="acf69078b8d23822a985e5768528d8af">
                  <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cc29f8a3f28c38489e96fc443b55a112">
                  <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e7500e246283317d87888a02b0fc7c94">
                  <SHORT-NAME>ILCSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ILCSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7c712f2ad80439f0b25ae49ae8d1bd1d">
                  <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMM_50ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="20958c087785303d9032b93365210226">
                  <SHORT-NAME>IMU_SN</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMU_SN</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9536044653c939e8ad1dd3fa0a5cbb3d">
                  <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPowerFailSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="310c38eba9703791824008e664da6347">
                  <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMaxTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="637774826d553076af0248c14c2b6c73">
                  <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMinTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="53934752b0973002b55c73822807cb8e">
                  <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGTqTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3ef7980e250f3d2c94db8be0535886d4">
                  <SHORT-NAME>IdentityChlg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IdentityChlg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="83b259ef8c5937a8a048de2f7d1f5203">
                  <SHORT-NAME>IgnOffTime</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTime</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="13934d64e5c73a1aba9f3be2bcccea26">
                  <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTimeV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="51191774f20632cf979b40e399a6e30d">
                  <SHORT-NAME>LCASelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCASelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="691d4b73f7d530bc9b1eb7dac9d253a6">
                  <SHORT-NAME>LCRSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6b8091c3d0cb3785b4cdc9414f781d86">
                  <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2a09562657b539709af9abacdc2fc28d">
                  <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKAHptWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="195fdb3c9025371e8ba0f1b31c872638">
                  <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4004d685491b3f769d3b6e89a33b819a">
                  <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f1e58c46d423340aa15df6ef1989ae92">
                  <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5c140d43fd213ed8b6e5d99fe0380023">
                  <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHSWPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="54c159b27a273646bbd28a879ceb7efa">
                  <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e73b3a84431a30089128ed34ffecea69">
                  <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_100ms_Group30</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ba96968eceb63f548a76e69799035266">
                  <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e39962f936303e8997f498abddc78b00">
                  <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f7cc3b4c8ea03f4c961f58c94e9546d6">
                  <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5eef19da8db531138a4e95738c051ef5">
                  <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_400ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6e4d2249c1e039579f0a5a6b4ebeac36">
                  <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d0095c3937763b859f2507563108868d">
                  <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a43e371fe8f831f6983f5ca91d76af68">
                  <SHORT-NAME>MONSAMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="763de1edaf1f3c15a58d8dce40bccf95">
                  <SHORT-NAME>MONTMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MONTMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fb357320f65335c8b4f0a17747da0f06">
                  <SHORT-NAME>MainBeamLghtOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0e7cf745336c30e680a520b612e9a5e4">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSlntPtrlEnbSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="084933c3751c3f3a9b8e9e7bae502933">
                  <SHORT-NAME>MemPkngSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemPkngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3822e2a484be3b998641abf5edd693f0">
                  <SHORT-NAME>MnvrngPntDistNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntDistNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="007a5ee1c5ad37269b2e0061eb276b97">
                  <SHORT-NAME>MnvrngPntTypNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MnvrngPntTypNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="017cdab61b7036629fa0b642ca2f97c1">
                  <SHORT-NAME>NOAETCSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c875f761f3b631f6b537fd4f1936bd95">
                  <SHORT-NAME>NOALaneSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="47aa11e703bb33a0aa632f1f261f8dca">
                  <SHORT-NAME>NOAQukChgSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="53fe6e9c8b0e3bc68421845453c5a416">
                  <SHORT-NAME>NOAReportSetSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1199800a955334208018b7c9e0b7eece">
                  <SHORT-NAME>NOPCitySwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b4ff5fd1ec1130768c0601fccee08ff9">
                  <SHORT-NAME>NOPSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8446a3b0cdf53d84a6a2fcf873026913">
                  <SHORT-NAME>NarRoVslAssQuit</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssQuit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="57ca705fcb1f345f9d7bd02b52c52261">
                  <SHORT-NAME>NarRoVslAssSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c201b14fd809366685b5db6a40121491">
                  <SHORT-NAME>NarwSpcAstSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="19aab7739d3e326cacf5a234938feb3f">
                  <SHORT-NAME>NavCndSpdLmtVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCndSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ba9d1ad96d493633ac4ac36533737543">
                  <SHORT-NAME>NavCrntRoadTyp</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCrntRoadTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a6e33fd777323e09963bc37e41c98d1c">
                  <SHORT-NAME>NavCtryCode_ISO</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavCtryCode_ISO</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="66454f595b3e31d79124502df20dbd10">
                  <SHORT-NAME>NavDistFromFrtEleccEye</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavDistFromFrtEleccEye</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="11093c8b00533e66b855a18e80084a7a">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavItvalSpdDetnDistRetDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f0b890949210302c8ec801d86f4cce44">
                  <SHORT-NAME>NavNewIconDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNewIconDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="408c817f41af3fa38ddc334bdff2e820">
                  <SHORT-NAME>NavNextRampOffset</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavNextRampOffset</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="efea2f36086a3c4cbd034bbefd61cf88">
                  <SHORT-NAME>NavSpdLmtTyp</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtTyp</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="69d50c6103993146bb815659a01a272d">
                  <SHORT-NAME>NavSpdLmtVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="287bf5193b693d82b516e697c8d3a3ac">
                  <SHORT-NAME>NavSpdLmtValSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="afca1db1af8f39a6b9ba8f6c256a6e9b">
                  <SHORT-NAME>NavSpdLmtValUnit</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSpdLmtValUnit</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0327fbb5bf4d3232b1d77938c1d60bee">
                  <SHORT-NAME>NavSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NavSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="500cf343f24b3803993717ccb0736b20">
                  <SHORT-NAME>NonDirectDMSSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9337bf8751673cba9a6074aeafe66cd8">
                  <SHORT-NAME>NorthVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NorthVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6758dbc830423556b012a8adfc3c2dd3">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5b5b726854c03e51984080a619b73250">
                  <SHORT-NAME>NrwroadBwdAssSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f70f545ac7ee3bb0a04f8a652a395849">
                  <SHORT-NAME>NrwroadFwdCtlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d184cce2d18b34beafee792b692df200">
                  <SHORT-NAME>NrwroadFwdReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bbfa58d3c99831ea8ae0bdb11776819f">
                  <SHORT-NAME>NrwroadsltReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="79bb3c993715319ead286d0d49ca5d38">
                  <SHORT-NAME>OnBdChrgrOptAltPwr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OnBdChrgrOptAltPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="62a3ca846ed036b9b8bc9a3cc60f917d">
                  <SHORT-NAME>OtsdAirTemCrVal</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrVal</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3d4bf6aabd813007b0a620b2661369bb">
                  <SHORT-NAME>OtsdAirTemCrValMsk</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValMsk</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d69bc27dda15368a912d55593041f2e1">
                  <SHORT-NAME>OtsdAirTemCrValV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/OtsdAirTemCrValV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3bb8106325423c4f9c7d7031a1f36716">
                  <SHORT-NAME>PEBSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="49c5a0a774b1348ab28180a87da7b524">
                  <SHORT-NAME>PEU_10ms_Group25</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEU_10ms_Group25</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b08499894ec836fdb83e40bc2b5338e2">
                  <SHORT-NAME>PICU_10ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a94e2cbead11351ea4ddfa00056fc053">
                  <SHORT-NAME>PICU_10ms_Group23</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="84552c8869fe3efda719b6556c258f48">
                  <SHORT-NAME>PICU_20ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1ba662eb35a33bdb943a3c60d37ea3ed">
                  <SHORT-NAME>PICU_PTAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PICU_PTAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ee85455541243d2192bf432cbf5055a5">
                  <SHORT-NAME>ParkngDirSw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="18b56eee30083b798f4724075408919a">
                  <SHORT-NAME>PositionAttitudeStatus</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PositionAttitudeStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af8589d487ae394c86b04cee9ac07c50">
                  <SHORT-NAME>PwrDMd_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrDMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="95cfdf53fc1f3104a50ed2d0a7adeaad">
                  <SHORT-NAME>PwrReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PwrReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2476bf4ed7203aa1835fa31cd6f68afc">
                  <SHORT-NAME>RACtlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RACtlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="82261ef586d634cd99657fbfe758b998">
                  <SHORT-NAME>RCTSysSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1f71c477142d3104a77aaac0283da72b">
                  <SHORT-NAME>RCWSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RCWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3fbcbd529a493be891d5f2369a782f6e">
                  <SHORT-NAME>RDASwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RDASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="030f6cfea6373463af804549296686e3">
                  <SHORT-NAME>RFCTWrnng_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="25a6c349d046312e85287a073a8ac1c5">
                  <SHORT-NAME>RFSDA_20ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFSDA_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e6a8c14bc9243b45990f13478bcdacf5">
                  <SHORT-NAME>RHRDA_50ms_Group04</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHRDA_50ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a6cc36f5e47b3262916a7fcc840b4945">
                  <SHORT-NAME>RHZCUAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0f4490856a54325e9d4c205dfbaae193">
                  <SHORT-NAME>RHZCU_100ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9fb01fc7056e3eccbf059ad97042e3d6">
                  <SHORT-NAME>RHZCU_50ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0a15e62e93dc3d7ca7abfa89d78250b4">
                  <SHORT-NAME>RHZCU_50ms_Group27</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCU_50ms_Group27</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="76af409bac6631588248764a84f1bb68">
                  <SHORT-NAME>RHZCUeFs1Sts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RHZCUeFs1Sts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60f8e8d8baa0315098b9e091c23c5c6a">
                  <SHORT-NAME>RLTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="73b5a4ddb8ab3b88aaeca14ce89a291a">
                  <SHORT-NAME>RLTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f6c1b1d772a3fd586e583147efedc2f">
                  <SHORT-NAME>RLTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9b744bd19447378c853c87fcc957357a">
                  <SHORT-NAME>RLTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0c02a87e92b233f4bc2cbb15540a77c5">
                  <SHORT-NAME>RLTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a0451546c49c366aa07a00a8ec33a6f6">
                  <SHORT-NAME>RRTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d99cb1e6d2a1370a969ed8bf9692a0ad">
                  <SHORT-NAME>RRTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bf78473044073d109c8612324dae9a82">
                  <SHORT-NAME>RRTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8dbd1b9304df3240b16e4b0cac714d3b">
                  <SHORT-NAME>RRTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2bf47a21844631cc8422e107a5cc7d5e">
                  <SHORT-NAME>RRTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8001b8e89d6d304abb71840795e6f05d">
                  <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnDiagSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="de482e53526c3a4188b5d36c16638bb3">
                  <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCUIgnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b7f6ce6f7325356bac2bbe9b20183f1c">
                  <SHORT-NAME>RZCU_100ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_100ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="08c37f4bbc0137f0af11f5f49fd907a4">
                  <SHORT-NAME>RZCU_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="00a16934e5323b55ba3bda55951ed35d">
                  <SHORT-NAME>RZCU_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="89159f3dd96c32bc9de57eda87691ae3">
                  <SHORT-NAME>RZCU_10ms_Group22</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group22</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="33f8af19575d30c883ab2e4ea8b689dc">
                  <SHORT-NAME>RZCU_10ms_Group23</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group23</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="97135f0ffae333eaacc6ecb629acbbd1">
                  <SHORT-NAME>RZCU_10ms_Group24</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group24</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4246c656455632dda6c8ace4d5d249bf">
                  <SHORT-NAME>RZCU_10ms_Group90</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_10ms_Group90</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="23fa4db00ab4355491f8254969236fa0">
                  <SHORT-NAME>RZCU_20ms_Group06</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_20ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a84043c36efd39ef901c69036c4e00da">
                  <SHORT-NAME>RZCU_50ms_Group37</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_50ms_Group37</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eec0b1b9d51f3b8da8888977af1b63b0">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_BKBCANFDAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1aa8412707693f6583b06deea8cfa5df">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RZCU_ZONE_10ms_Group64</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="946af48744e233939e03440f3e1acf07">
                  <SHORT-NAME>ResetCnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ResetCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1dc1a09b7dd1302da475b6bfdf065210">
                  <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Rolloff2Min_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b11428b530723a3691b93c4747f34edd">
                  <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RolloffHld_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="57f210f95f57338eb09db22a4e590264">
                  <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="874b0a60fb5f3b7ba1622e605905c3b8">
                  <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RstrFctryDeftsReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="40903672974f398f9c2ca83758cc19bc">
                  <SHORT-NAME>SDMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ace350fe341d3473b97ed7eb4ceecb79">
                  <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a8f54b1f19363c3cb00c2537606dd739">
                  <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="55cb1de7281633d48574b4696500d0a2">
                  <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60c1b683006c31d58bb87b8edd549afc">
                  <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5b5b89186803ca6bc58c40271f8e749">
                  <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="681bc15bdf9034b79a6555d8d3707b74">
                  <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLowPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="be6c7d7dd2d03b3eb82038e9edf62681">
                  <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLvl_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="01aad28e5bbe3a6794fac4897bb211b9">
                  <SHORT-NAME>SOCMd_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5b535692f9436c0a2cd5b1d6c27c5b0">
                  <SHORT-NAME>SatAz1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2e301e1c46d43338b05d1262b2dcc99d">
                  <SHORT-NAME>SatAz10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="274331a19a5a31b5a24ac478fa2e3fcb">
                  <SHORT-NAME>SatAz11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6f03342dd30c30c49268a701fda38840">
                  <SHORT-NAME>SatAz12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0b9cf00d0038312e852f5e08780efd2a">
                  <SHORT-NAME>SatAz13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fc735d715dc532d0969791ea125ea400">
                  <SHORT-NAME>SatAz14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8af8010d360d35e9b9e592de2bbc75fb">
                  <SHORT-NAME>SatAz15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="512a51fea80b339d935f0c9857ed9959">
                  <SHORT-NAME>SatAz16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2d1f11b955363d3d94944b9cb9ee5bca">
                  <SHORT-NAME>SatAz17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ec21e86d77823d2ca5086a88475a23d6">
                  <SHORT-NAME>SatAz18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="449fd0240abc39c8b949882c5022a86c">
                  <SHORT-NAME>SatAz19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5db055d0207d31399969e531f4c18341">
                  <SHORT-NAME>SatAz2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e175b5dedc3b347898cad62610b45062">
                  <SHORT-NAME>SatAz20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2f7ca8a212f034beb8f986a935431877">
                  <SHORT-NAME>SatAz3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="df2735b4b98b3eed89750f906fca906c">
                  <SHORT-NAME>SatAz4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2738e94c698b326ebca07385d7c095f4">
                  <SHORT-NAME>SatAz5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3ced27a3e57633359d6955142d7fbb31">
                  <SHORT-NAME>SatAz6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e27abcf156ca33b0a0a25d76da24cd8a">
                  <SHORT-NAME>SatAz7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d5c428b11d63959b265a59fbdf4e085">
                  <SHORT-NAME>SatAz8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eb783c4c17643a85849782417deea8f9">
                  <SHORT-NAME>SatAz9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="26306a0258e73dab975d2a7f001c8d66">
                  <SHORT-NAME>SatCNO1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="689fc02dfb7032298e1dc4bc3c76f4fd">
                  <SHORT-NAME>SatCNO10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b956bb1f7e9d3978b39e1d3dc6e8f92d">
                  <SHORT-NAME>SatCNO11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="18b88b4caaa13bea803770c024f6ab47">
                  <SHORT-NAME>SatCNO12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d2371ffba0ce33feb1db579552b8a1f3">
                  <SHORT-NAME>SatCNO13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c2114d26fba73e4d8f6c3ba603689f33">
                  <SHORT-NAME>SatCNO14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="24010a61d83c3fcf951aaa80abc96d9e">
                  <SHORT-NAME>SatCNO15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="57c889d58f20305483b51f757105cb61">
                  <SHORT-NAME>SatCNO16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5de4ded59ca39f48b08a2f5c4513d9d">
                  <SHORT-NAME>SatCNO17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c94ae44510ad3c968fb825130472175b">
                  <SHORT-NAME>SatCNO18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8dfa9bc352ef3a31ae2dfce094c6ab6c">
                  <SHORT-NAME>SatCNO19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d6cc83b3270e30d1a33e437f099b5d29">
                  <SHORT-NAME>SatCNO2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7f46e09322b13495a698294abe2ccb5a">
                  <SHORT-NAME>SatCNO20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c71565468ef13ac38831740376343ef1">
                  <SHORT-NAME>SatCNO3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cb9fed52675b39d486916e2fa06ef4b7">
                  <SHORT-NAME>SatCNO4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="94c6b04345283c9ba01ab3986e6fd91b">
                  <SHORT-NAME>SatCNO5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d53f840ca8f63ac1992bc788685804eb">
                  <SHORT-NAME>SatCNO6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a725e19a97c0377d92a9586a04bda9ef">
                  <SHORT-NAME>SatCNO7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eb0afe5457bb3d6296b8124e04606f16">
                  <SHORT-NAME>SatCNO8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3a4c89de45a83152b8be0f4044ff3b84">
                  <SHORT-NAME>SatCNO9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5072c3296cc83a0d88aab168fd1148ae">
                  <SHORT-NAME>SatElv1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="503037d23770359281c577742a598f76">
                  <SHORT-NAME>SatElv10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="77fc24c6f7b63433bf758364180a8162">
                  <SHORT-NAME>SatElv11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e1d3f786204e30c38ad5dcc272b84770">
                  <SHORT-NAME>SatElv12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5fc0a6942b9f3068a29a8b2d426a46fc">
                  <SHORT-NAME>SatElv13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1ecb1c44b75733e5a59f416e33049a63">
                  <SHORT-NAME>SatElv14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e96bf398c39f3b5788441e793d072f5b">
                  <SHORT-NAME>SatElv15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c4f1aeebeb3f3897afca89cc25113f81">
                  <SHORT-NAME>SatElv16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7795625e4860308282f6c9e5d70d512b">
                  <SHORT-NAME>SatElv17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0f0895ee479938a2853308d62f566d7f">
                  <SHORT-NAME>SatElv18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5ec3913aafd83be58ed97c135f07a2a6">
                  <SHORT-NAME>SatElv19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f709159bed9033beb3292c16d62fd848">
                  <SHORT-NAME>SatElv2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b4fa3e6a6f8e3bac8e56eedd28386ac9">
                  <SHORT-NAME>SatElv20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c595aaf99ecb3c538494b8c1033b0f59">
                  <SHORT-NAME>SatElv3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2cce76ac6f12303eaee8cdf76a614dd3">
                  <SHORT-NAME>SatElv4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="75b1649a8bf139ef9ee8fbc6c34037f5">
                  <SHORT-NAME>SatElv5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="17193f30ae303fda82df60a79bd8a639">
                  <SHORT-NAME>SatElv6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="511bb160cd6b320cb7e170ee73c8b30a">
                  <SHORT-NAME>SatElv7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c4c3bb6d34e23744a0d7ca93ff2e7a48">
                  <SHORT-NAME>SatElv8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c9fdd14f5746390ab6a6b64b88b3c924">
                  <SHORT-NAME>SatElv9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6ae5a17a09a836a19bbc24dbca3763ca">
                  <SHORT-NAME>SatID1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="90c4f38894263032b2e8c725c10685b1">
                  <SHORT-NAME>SatID10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="60673081c18d3de3854974c419027773">
                  <SHORT-NAME>SatID11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b01012bf16783cbaa33936915f374fdc">
                  <SHORT-NAME>SatID12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cb2a34661ebf3bdd8e0511ba10b248a5">
                  <SHORT-NAME>SatID13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0a4ec9c9df553231a5b4b14e8f3a3fd1">
                  <SHORT-NAME>SatID14</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1eed367e03a33bba935304170df95937">
                  <SHORT-NAME>SatID15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af0f910cc4fa387b8bc27e51a917e0d2">
                  <SHORT-NAME>SatID16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7695eb5ab06d34688bd337c251c43734">
                  <SHORT-NAME>SatID17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="810675705998301eb7f024376c3ff424">
                  <SHORT-NAME>SatID18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="06afec1fc3ba3122851cd0c7d57213e5">
                  <SHORT-NAME>SatID19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af2901ba8ef534be901cfa94225e901a">
                  <SHORT-NAME>SatID2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f2040b534513374694cce9bee3cd72f6">
                  <SHORT-NAME>SatID20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d34a5db0e57639669f7e505adbf787fb">
                  <SHORT-NAME>SatID3</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f0383cc5a3853bc6ac577ac2c35ab2cf">
                  <SHORT-NAME>SatID4</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="034d4b9728ef35eca3ae53909547c031">
                  <SHORT-NAME>SatID5</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d29fb44aea223eb294be5eed0e4eae43">
                  <SHORT-NAME>SatID6</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="84c8bf6e15b13f89b521ef5daa27c6d6">
                  <SHORT-NAME>SatID7</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="333db89058d23bf3ac43090047a50060">
                  <SHORT-NAME>SatID8</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2726fe3308c83268b9ecebbfcc5ee089">
                  <SHORT-NAME>SatID9</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ffccbec9ec9f3779902f88e32d8894c0">
                  <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInAttitudeRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4825db2dff3f3996b36600858c2e8f78">
                  <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInPositionRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d1e74cb2aff23a7b9d0377851f1cb0e7">
                  <SHORT-NAME>SatNum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9cd567d40e203db8be230343e398b2f1">
                  <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SeatOccptnNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b3c711553931303782d7aa651332754a">
                  <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ShftSeqStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ac9a53d35bef3b4ea95669431a01ed0a">
                  <SHORT-NAME>SideLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SideLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f9907804254372abdd66df19809302b">
                  <SHORT-NAME>SpdLmtNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="04dbba7deac3309ab89ad0178164e88e">
                  <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d504aa1ce4634de96c8d12a47e462f6">
                  <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bb391a9e950d3d6fa39c36d6ea04c93b">
                  <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7628c10ba3633e24b553308530477062">
                  <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtPathRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="021f6d0804c93f4993684b350193c348">
                  <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="afb3d700361730fd8a4cbb3c9e51e375">
                  <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/StrtTypAvail_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="20e741d7a4f933f088b11fae6a885130">
                  <SHORT-NAME>SvGroup</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SvGroup</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="782b6ec8d70b398a912a5e8e9f2007f6">
                  <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASSAMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="295c06e07af837d5bebf90041c0c9f62">
                  <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASTMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="71e8a571feaa3e2c95e8c9a05b065ed1">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_020ms_PDU18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="57b70313ee663f98b602be10d73dca40">
                  <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f798c0c9e4a73620830837ab92f70bc0">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_PDU20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="481cd3fcd5bf389e8d7d4837f8da5882">
                  <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_PTCAN_FrP05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a330527d8d363c5797a4be6c12ca9cd6">
                  <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvSAMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e6ac534ac39a3add8e9b191923c32e01">
                  <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvTMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="77fef8e8f6a03ab981a3fd32a628fa54">
                  <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUOpSt_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d93b57c20c5439e6ab5dee6c388d0ab4">
                  <SHORT-NAME>TDMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6588efbed035389a9af3e95261c777d1">
                  <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDM_200ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8964494fbb6330ecb8ced90848fe9ad9">
                  <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e31604006f5b36b5941d94ce6618f104">
                  <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSBtmNosRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5d9a7f10bd530349c0f0f56e238df17">
                  <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="394083523bfa3a0cb1caa72ff52de7d9">
                  <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrIDLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a4d85a1c50733751a04ccc92a368ffbb">
                  <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1fb5285a3bb6375193d8a9d59f31d254">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="682a498267453a2db5b89bf51654755d">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtrLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="56ee1c28403d376ebb3b1ed20566747e">
                  <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSWntrMdA</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cebff37fcf7e38669da7cc99de4a2d3b">
                  <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TQRTMTqReq_N</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="351985e471d93475be898c213e39f090">
                  <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b8b716d3d1963e7da1200e7bf907085c">
                  <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCTqDmdSTC_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0790c05f18c830ca90b9ec158648e566">
                  <SHORT-NAME>TSRSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a13db2b1407c31f5b2b17ce04a6f7414">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMMaxTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="291f11a4b012300d9bcdc5cbddde3ade">
                  <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="24623d111d7e3321bb6ed80215fa48b8">
                  <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TemSnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d4ab5a28e0a43f6eadc72b70b7d9808d">
                  <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TqCtrlStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fa3d53da24a630eca3df1ab46a810f3e">
                  <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnKeyBtnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="12e11114cb3d3738aae4bd4ef64dafec">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyFindCarSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7f4eba0ef99d3bdabc48c3939c01aef0">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="65fc3724c4d03a5a81cde1162934cf3b">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLdspcSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="676f0607136d37eba58d2a2fa7768b5b">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyUnlckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="243a71eb668531f38e8aa7ca680be772">
                  <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcForbidDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b20106879cac3d0681948b75d6d1e9e8">
                  <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcInfoSignDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cc566b222b5d3befa7124d2bc2ea5866">
                  <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcJamRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c83100ec9669387790336b6927803b15">
                  <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ac1fadb3f0c239e4aae61bb113a189ed">
                  <SHORT-NAME>TripCnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e50d156a0b4e388bbf346b1e2c096eae">
                  <SHORT-NAME>TripCntResetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCntResetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="07a72e683b31336f9ba18212553f6eb6">
                  <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VDCSlipCtrlSts_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bbd89e85a9d2394bb08feabdfb99b6ed">
                  <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshDay</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="39eebf53f3333f3c80ccf8d877774e4d">
                  <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshHr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="20300be464053ddf93e1579af07e030c">
                  <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMins</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="677790a1a27d39959d9608940ec922ea">
                  <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMth</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bc6de0cc6ef03d2a9479503db2ac6b9f">
                  <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshSec</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eae62eb52cab3f1a82e2c026b8c64890">
                  <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshYear</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eee7926896033d17a1686c6f46b006c4">
                  <SHORT-NAME>Veldownsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veldownsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9b2a5fe892903d1aa851945dd712f8e5">
                  <SHORT-NAME>Veleastsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veleastsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="36075b16a6da3138b9ea1c408cf5cbda">
                  <SHORT-NAME>Velnorthsigma</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Velnorthsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ebc34948d24631ebab9f160b44764b9d">
                  <SHORT-NAME>WhlRghRoad</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="130bd4ad6b483c2ba2195cccc5e090d6">
                  <SHORT-NAME>WhlRghRoadV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoadV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
              </PORTS>
              <COMPONENTS>
                <SW-COMPONENT-PROTOTYPE UUID="Na505a3f19f25843c4b2f23dXNa505a3f19f25843c4b2f23c00">
                  <SHORT-NAME>IPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-SW-COMPONENT-TYPE">/SoftwareTypes/ComponentTypes/IPD</TYPE-TREF>
                </SW-COMPONENT-PROTOTYPE>
              </COMPONENTS>
              <CONNECTORS>
                <DELEGATION-SW-CONNECTOR UUID="be0feb9728963aceb9fa20127743341e">
                  <SHORT-NAME>ACCConfmSwReq_IPD_ACCConfmSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCConfmSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCConfmSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="75b385cc74613536bee5b0738737f015">
                  <SHORT-NAME>ACCConfmSw_IPD_ACCConfmSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCConfmSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCConfmSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4bb6048e15d13a33b06b0034686179ee">
                  <SHORT-NAME>ACCCurveSpdSwReq_IPD_ACCCurveSpdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCCurveSpdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCCurveSpdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b56fa8482b043db3a2f3735fe74ff0ea">
                  <SHORT-NAME>ACCCurveSpdSw_IPD_ACCCurveSpdSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCCurveSpdSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCCurveSpdSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48ebc550f18f39cfb1ac393cca1482f9">
                  <SHORT-NAME>ACCDetObj1ExistPrblty_IPD_ACCDetObj1ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa8625ab249d33c4855baed54631f981">
                  <SHORT-NAME>ACCDetObj1Id_IPD_ACCDetObj1Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4649fd9cd2933812aee4df5df3ebcd93">
                  <SHORT-NAME>ACCDetObj1LatRltvDist_IPD_ACCDetObj1LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="41e31f1ae34635ff9a7721e912de758a">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist_IPD_ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="417ba144eac0342380fdd2b53cf2f0c0">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd_IPD_ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="910c6be839523a37b6466ca968278161">
                  <SHORT-NAME>ACCDetObj1Risk_IPD_ACCDetObj1Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c402453fd22931fb8734e06a579e8031">
                  <SHORT-NAME>ACCDetObj1SyncCtr_IPD_ACCDetObj1SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59676376ee2030e2831c92103b929f93">
                  <SHORT-NAME>ACCDetObj1Typ_IPD_ACCDetObj1Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj1Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj1Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c4f58f3a1e53d61864c7d2f0b3595cd">
                  <SHORT-NAME>ACCDetObj2ExistPrblty_IPD_ACCDetObj2ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="609849fb0027308c8dee23da0fc91557">
                  <SHORT-NAME>ACCDetObj2Id_IPD_ACCDetObj2Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e37475b98d943fc9a3054c31260c1346">
                  <SHORT-NAME>ACCDetObj2LatRltvDist_IPD_ACCDetObj2LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a5abd248ada3c16ac86325cbfdea282">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist_IPD_ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f7a6984f45a13a82b81e4873c221ebc3">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd_IPD_ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd6d7e8fbf9939e390cbc5368bd94a8c">
                  <SHORT-NAME>ACCDetObj2Risk_IPD_ACCDetObj2Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45fa6ebdc01a31a8ac6366f481c76905">
                  <SHORT-NAME>ACCDetObj2SyncCtr_IPD_ACCDetObj2SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0edadf051123e0cac31e824035bcbfe">
                  <SHORT-NAME>ACCDetObj2Typ_IPD_ACCDetObj2Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj2Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj2Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a92659ca9373a77a14bf6f84b900afb">
                  <SHORT-NAME>ACCDetObj3ExistPrblty_IPD_ACCDetObj3ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d0334d934af3f1cb3b2eae89f07e770">
                  <SHORT-NAME>ACCDetObj3Id_IPD_ACCDetObj3Id</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3Id</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Id</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b4d8ac3c350f36beba1f98e0a573d5ea">
                  <SHORT-NAME>ACCDetObj3LatRltvDist_IPD_ACCDetObj3LatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3LatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0906414cea903cd78bb87b87efd15441">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist_IPD_ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3LongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b89f1ca3265939818b92f9261cd8e2e2">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd_IPD_ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3LongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3LongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1dfc967608aa38cb81605f217e20f327">
                  <SHORT-NAME>ACCDetObj3Risk_IPD_ACCDetObj3Risk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3Risk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Risk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aa463c18185d3d949b267dd3c485db14">
                  <SHORT-NAME>ACCDetObj3SyncCtr_IPD_ACCDetObj3SyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3SyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3SyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1bf7aeca8f1636bc90f6355a2a358051">
                  <SHORT-NAME>ACCDetObj3Typ_IPD_ACCDetObj3Typ</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObj3Typ</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObj3Typ</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="808cb2610473340ab9459803c764cefc">
                  <SHORT-NAME>ACCDetObjExistPrblty_IPD_ACCDetObjExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0e022b1db16b3e25b9ecb6bacc13264f">
                  <SHORT-NAME>ACCDetObjHdngAng_IPD_ACCDetObjHdngAng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjHdngAng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjHdngAng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="515dc6625e733bacb736cefdd6a972bb">
                  <SHORT-NAME>ACCDetObjId_IPD_ACCDetObjId</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjId</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjId</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34a0e39b1fce3b66bc219653cdcbf550">
                  <SHORT-NAME>ACCDetObjLatRltvDist_IPD_ACCDetObjLatRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjLatRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLatRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="342d771c8bb532c4ad9cf34a504ba39b">
                  <SHORT-NAME>ACCDetObjLongtRltvDist_IPD_ACCDetObjLongtRltvDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjLongtRltvDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLongtRltvDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="91bfd19ca0a53a20943124b6034ee75a">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd_IPD_ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjLongtRltvSpd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjLongtRltvSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="69e2578fc3e431bdad379fa38e1ddb4a">
                  <SHORT-NAME>ACCDetObjRisk_IPD_ACCDetObjRisk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjRisk</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjRisk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="86b1b1cf420b3721b0dffef4c7e07470">
                  <SHORT-NAME>ACCDetObjSyncCtr_IPD_ACCDetObjSyncCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjSyncCtr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjSyncCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ababb83e3011353391fd37f59de84653">
                  <SHORT-NAME>ACCDetObjTyp_IPD_ACCDetObjTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDetObjTyp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDetObjTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="afe628da539e37e08b76749306bd254c">
                  <SHORT-NAME>ACCDrvrTkovReq_IPD_ACCDrvrTkovReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCDrvrTkovReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCDrvrTkovReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="27c167b6e119367a920ea4a9e6a10eca">
                  <SHORT-NAME>ACCObjDet_IPD_ACCObjDet</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCObjDet</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCObjDet</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="499ab107e54e3cf498e63bab491b3c24">
                  <SHORT-NAME>ACCSpdLimtSwReq_IPD_ACCSpdLimtSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCSpdLimtSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCSpdLimtSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fb42bdde7f8d3f8c8e5a44c03e896bc8">
                  <SHORT-NAME>ACCSpdLimtSw_IPD_ACCSpdLimtSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCSpdLimtSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCSpdLimtSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f0487e33326f32a6b98af68243a158d1">
                  <SHORT-NAME>ACCStsForEdr_IPD_ACCStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bd667454310d3f42bba121a71c619b66">
                  <SHORT-NAME>ACCStsSwReq_IPD_ACCStsSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCStsSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f5b715a41d7936b98679f0a033b8566d">
                  <SHORT-NAME>ACCStsSw_IPD_ACCStsSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCStsSw</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCStsSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="24918b5603883cedba840abc0af166d8">
                  <SHORT-NAME>ACCTJAMdSwReq_IPD_ACCTJAMdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACCTJAMdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACCTJAMdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f8ef28e3bcb83846a42df77c7db20a80">
                  <SHORT-NAME>ACSFCatgrAStsForEdr_IPD_ACSFCatgrAStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrAStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrAStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="560a29f64721316fb23857d46bfde194">
                  <SHORT-NAME>ACSFCatgrB1StsForEdr_IPD_ACSFCatgrB1StsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrB1StsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrB1StsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bd3395728cfc3baba6c6116d91784948">
                  <SHORT-NAME>ACSFCatgrB2StsForEdr_IPD_ACSFCatgrB2StsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrB2StsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrB2StsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d083d21c8a03ae6825f3e1bffbe8c89">
                  <SHORT-NAME>ACSFCatgrCStsForEdr_IPD_ACSFCatgrCStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrCStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrCStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="88e3783623e4393bb0c8a1d1b8fbb3ed">
                  <SHORT-NAME>ACSFCatgrDStsForEdr_IPD_ACSFCatgrDStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrDStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrDStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4a13526fed6a367f9bffab635bfab425">
                  <SHORT-NAME>ACSFCatgrEStsForEdr_IPD_ACSFCatgrEStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ACSFCatgrEStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ACSFCatgrEStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="66f6fd38f29f35a3863c639cd92ad908">
                  <SHORT-NAME>ADAudioSWReq_IPD_ADAudioSWReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ADAudioSWReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADAudioSWReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f4be0071d1173e0ba9b5327e561d02ab">
                  <SHORT-NAME>ADAudioSWSts_IPD_ADAudioSWSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ADAudioSWSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADAudioSWSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8b08ce21a98836c0b759d5dc8e12c0b2">
                  <SHORT-NAME>ADS_ISAMsgReq_IPD_ADS_ISAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ADS_ISAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f2b9a6ac6093f0f9d17ff2859b2191d">
                  <SHORT-NAME>ADS_ISASysFltSts_IPD_ADS_ISASysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ADS_ISASysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISASysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f41d2c486c9631ceb704fe65f27fbc36">
                  <SHORT-NAME>ADS_ISASysSts_IPD_ADS_ISASysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ADS_ISASysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ADS_ISASysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="116e3b0a60e03c21a8fcfb7353e43a74">
                  <SHORT-NAME>AEBDspCmd_IPD_AEBDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AEBDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a2ca6f017403755b28a07b4e86149f2">
                  <SHORT-NAME>AEBMsgReq_IPD_AEBMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AEBMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="74fddc0b446c3fb1a311151a20986ad0">
                  <SHORT-NAME>AEBStsForEdr_IPD_AEBStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AEBStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cff110aad5173be5a9a69e7d5d34a5f0">
                  <SHORT-NAME>AEBSwReq_IPD_AEBSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AEBSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AEBSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c86ee739b58236708084ee3c6006ee68">
                  <SHORT-NAME>AIParkngDsp_IPD_AIParkngDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e8ff7da4193a38f783208e4c1a96507a">
                  <SHORT-NAME>AIParkngEPAMdsts_IPD_AIParkngEPAMdsts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngEPAMdsts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngEPAMdsts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e239e6ff02e3cd2bb198deaf60a79a8">
                  <SHORT-NAME>AIParkngEPAMdsw_IPD_AIParkngEPAMdsw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngEPAMdsw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngEPAMdsw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bcfe5f49b80a307a897d68ef2b663b31">
                  <SHORT-NAME>AIParkngReqICB_IPD_AIParkngReqICB</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngReqICB</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReqICB</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9cef9bf9ad8234c7b8b8533d86b88b09">
                  <SHORT-NAME>AIParkngReq_IPD_AIParkngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cb6d2a7a6d253dbdb855cbc55cc5551f">
                  <SHORT-NAME>AIParkngReq_ZXD_IPD_AIParkngReq_ZXD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngReq_ZXD</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngReq_ZXD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4dbd17d553e13e10952166dac54bffb4">
                  <SHORT-NAME>AIParkngRespICB_IPD_AIParkngRespICB</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngRespICB</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngRespICB</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a31b24106f32325780bf6755bb19bce5">
                  <SHORT-NAME>AIParkngSSPLotSwSts_IPD_AIParkngSSPLotSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngSSPLotSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSSPLotSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d9bbf45508e39d7850e52058d1dbf6b">
                  <SHORT-NAME>AIParkngSSPLotSw_IPD_AIParkngSSPLotSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngSSPLotSw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSSPLotSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="853795b1efdb3310b54a25ce9cafac76">
                  <SHORT-NAME>AIParkngSpcID_IPD_AIParkngSpcID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngSpcID</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSpcID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9cd72867174b3d49bada6c3689fd49da">
                  <SHORT-NAME>AIParkngSpdsw_IPD_AIParkngSpdsw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngSpdsw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSpdsw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0e62c25d65c381a92dc734fbdb3bd21">
                  <SHORT-NAME>AIParkngSts_IPD_AIParkngSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIParkngSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIParkngSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e35344fc9684364db6ab1b4309fa5f35">
                  <SHORT-NAME>AIPilotIntervQuit_IPD_AIPilotIntervQuit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AIPilotIntervQuit</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AIPilotIntervQuit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a368f890190b317085f68cb2752e1bfc">
                  <SHORT-NAME>APAOneKeyParkSwReq_IPD_APAOneKeyParkSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APAOneKeyParkSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAOneKeyParkSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ae1b920bf4153acd8030e671c2a6a1f5">
                  <SHORT-NAME>APAParkInOffsetTypeReq_IPD_APAParkInOffsetTypeReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APAParkInOffsetTypeReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAParkInOffsetTypeReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57e10fdc42733a8984255b3d5654e94e">
                  <SHORT-NAME>APAParkInOffsetType_IPD_APAParkInOffsetType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APAParkInOffsetType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APAParkInOffsetType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="27a9152777ee3cfe8ab2d09fe9ef4a10">
                  <SHORT-NAME>APARemShifGear_IPD_APARemShifGear</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APARemShifGear</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APARemShifGear</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d121a6dbcfcf3319a00c4b32aa8aa52b">
                  <SHORT-NAME>APASWReq_IPD_APASWReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APASWReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASWReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c74669f3389a3894b5c780eb3cf73b7f">
                  <SHORT-NAME>APASW_IPD_APASW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APASW</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e9bf22dfbb73612bacd12b04133370c">
                  <SHORT-NAME>APASpdMdSwSts_IPD_APASpdMdSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/APASpdMdSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/APASpdMdSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="360fc54652523c38a693f9f07153b0a3">
                  <SHORT-NAME>AVMDspReq_IPD_AVMDspReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AVMDspReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVMDspReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="604492e03212339487bb1319fac3cf6d">
                  <SHORT-NAME>AVMSt_IPD_AVMSt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AVMSt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVMSt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="626053daa34e37b39251c4328db59c16">
                  <SHORT-NAME>AVPMapRutMgIDtReq_IPD_AVPMapRutMgIDtReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AVPMapRutMgIDtReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AVPMapRutMgIDtReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3d79111cb4de322b8611aea60b5dc729">
                  <SHORT-NAME>AutoLaneChngSetReq_IPD_AutoLaneChngSetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AutoLaneChngSetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngSetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="714c52ad0b8e3daf844ec2f0eef0e226">
                  <SHORT-NAME>AutoLaneChngSwReq_IPD_AutoLaneChngSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AutoLaneChngSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e3055e9edb5834239faf55313b2f6ed8">
                  <SHORT-NAME>AutoLaneChngVcCmd_IPD_AutoLaneChngVcCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AutoLaneChngVcCmd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoLaneChngVcCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de50919400423904a663628df83071a7">
                  <SHORT-NAME>AutoMainBeamLghtOn_IPD_AutoMainBeamLghtOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AutoMainBeamLghtOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoMainBeamLghtOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fbdd52a418303ffda26d7a7dd08b0fc4">
                  <SHORT-NAME>AutoMainBeamLghtReq_IPD_AutoMainBeamLghtReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/AutoMainBeamLghtReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/AutoMainBeamLghtReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca0dfe8915a3398eb11d4213b84c1384">
                  <SHORT-NAME>BSDSelReq_IPD_BSDSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/BSDSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/BSDSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3e9257865ec833268593ede98693999a">
                  <SHORT-NAME>BaseLineLen_IPD_BaseLineLen</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/BaseLineLen</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/BaseLineLen</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a3415b6206a53d4a897e89343b37e65b">
                  <SHORT-NAME>CANprotocolinternalversion_IPD_CANprotocolinternalversion</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CANprotocolinternalversion</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CANprotocolinternalversion</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a16e3055bd083c0ab888a3068053aba1">
                  <SHORT-NAME>CCSpdVcCmdCnfm_IPD_CCSpdVcCmdCnfm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CCSpdVcCmdCnfm</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCSpdVcCmdCnfm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59f88159eff130baa768a50e9096b16b">
                  <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd_IPD_CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CCSpdlVcCmdSwReqDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCSpdlVcCmdSwReqDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="65ad80957f793365805eaa5994990adb">
                  <SHORT-NAME>CCU_100ms_Group02_IPD_CCU_100ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CCU_100ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3836756b38043a3288c20180d0e123c5">
                  <SHORT-NAME>CCU_100ms_Group07_IPD_CCU_100ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CCU_100ms_Group07</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a6bffb28f0f3d90a5dc73ea25989bb8">
                  <SHORT-NAME>CCU_100ms_Group11_IPD_CCU_100ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CCU_100ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CCU_100ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d66d08fc3d7b33a689d877e2e722f20c">
                  <SHORT-NAME>CSFStsForEdr_IPD_CSFStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/CSFStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/CSFStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2cd994320e9331f68892af54c79ce508">
                  <SHORT-NAME>ChrgPwrReq_kW_IPD_ChrgPwrReq_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ChrgPwrReq_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ChrgPwrReq_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4892a367acf1385389067843140c2c5f">
                  <SHORT-NAME>ChrgReq_flg_IPD_ChrgReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ChrgReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ChrgReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a26dbd5f66f934d08ce6d972b1bcc5ff">
                  <SHORT-NAME>ClstrDspdVehSpd_mph_IPD_ClstrDspdVehSpd_mph</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ClstrDspdVehSpd_mph</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ClstrDspdVehSpd_mph</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57370c7941c932b38a3ec19d87475234">
                  <SHORT-NAME>ComKeyEnbReq_IPD_ComKeyEnbReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ComKeyEnbReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ComKeyEnbReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="46c02f24d6ff3706b92a264cb47cf5f2">
                  <SHORT-NAME>D2DPriETClanSwReqResps_IPD_D2DPriETClanSwReqResps</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/D2DPriETClanSwReqResps</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DPriETClanSwReqResps</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="646b29a74c2a39d2b1bf8cb926c476b2">
                  <SHORT-NAME>D2DPriETClanSwReq_IPD_D2DPriETClanSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/D2DPriETClanSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DPriETClanSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="54e3b018551a3bd88fcc463f766ffc6e">
                  <SHORT-NAME>D2DSwReqResps_IPD_D2DSwReqResps</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/D2DSwReqResps</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSwReqResps</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3dcee5abd98e3f0d84e443d11a81204d">
                  <SHORT-NAME>D2DSwReq_IPD_D2DSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/D2DSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5177ff49c72b3604b7405df809dd15a7">
                  <SHORT-NAME>D2DSysSts_IPD_D2DSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/D2DSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/D2DSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c8a2c4b2bcb3495a10e7d84982b0d76">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0_IPD_DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DFC_Current_DisplyBuffer_0</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0b65079b81f03dbda5d20bb40d6a74c4">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1_IPD_DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DFC_Current_DisplyBuffer_1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f8aedeebd2c2382da2917f77d1ed8845">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2_IPD_DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DFC_Current_DisplyBuffer_2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DFC_Current_DisplyBuffer_2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a5cd5c5c078237a6b9aab9df094380e5">
                  <SHORT-NAME>DMSCameraFps_IMM_IPD_DMSCameraFps_IMM</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DMSCameraFps_IMM</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DMSCameraFps_IMM</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="50fc07f836513009a17e8e8721e5c5c5">
                  <SHORT-NAME>DOWSelReq_IPD_DOWSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DOWSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DOWSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a72bc38e47d3d4b8974acd8e149186a">
                  <SHORT-NAME>DTCInfomationIPD_IPD_DTCInfomationIPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DTCInfomationIPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DTCInfomationIPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4132940741c238e1b03013bdfa1d03c6">
                  <SHORT-NAME>DetourMsgReq_IPD_DetourMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DetourMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DetourMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a1d64d3ebe0b359f8f666970db513d4b">
                  <SHORT-NAME>DfstOnDspCmd_IPD_DfstOnDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DfstOnDspCmd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DfstOnDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5496ee6611034cba0feb9db367135b8">
                  <SHORT-NAME>DiffAgeInfo_IPD_DiffAgeInfo</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DiffAgeInfo</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DiffAgeInfo</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3c72ec54667e3ea785222ed57018a81c">
                  <SHORT-NAME>DiffDataLinkBroken_IPD_DiffDataLinkBroken</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DiffDataLinkBroken</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DiffDataLinkBroken</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fd7a04f0e08337f2b6a68eb304372ca8">
                  <SHORT-NAME>DircnIndLghtMdSts_IPD_DircnIndLghtMdSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DircnIndLghtMdSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DircnIndLghtMdSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9a8de4ca31e53fcf9731598b8be9f3e2">
                  <SHORT-NAME>DircnIndLghtSwSts_IPD_DircnIndLghtSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DircnIndLghtSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
