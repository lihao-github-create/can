              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccd44XOa505a3f19f25843c4b1ccd4300">
              <SHORT-NAME>PEUAccryPwrModuOpngMd</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAccryPwrModuOpngMd_0_Standby</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAccryPwrModuOpngMd_1_Work</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAccryPwrModuOpngMd_2_Error</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccdbdXOa505a3f19f25843c4b1ccdbc00">
              <SHORT-NAME>PEUAccryPwrModuOtptPwrAvlbl</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUAccryPwrModuOtptPwrAvlbl</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1023.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>10.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUAccryPwrModuOtptPwrAvlbl</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10230.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccdf4XOa505a3f19f25843c4b1ccdf300">
              <SHORT-NAME>PEUAccryPwrModuTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUAccryPwrModuTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUAccryPwrModuTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cce2bXOa505a3f19f25843c4b1cce2a00">
              <SHORT-NAME>PEUAccryPwrModuTemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAccryPwrModuTemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAccryPwrModuTemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207bdeXOa505a3f19f25843c4b207bdd00">
              <SHORT-NAME>PEUEmsnRltdMalfA</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUEmsnRltdMalfA_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUEmsnRltdMalfA_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a20f8XOa505a3f19f25843c4b2a20f700">
              <SHORT-NAME>PEUFltDsp</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUFltDsp</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_0_Normal</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_1_Warning</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_2_PowerDerating</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_3_Reserve</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_4_Reserve</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_5_Reserve</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_6_Reserve</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltDsp_7_Reserve</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207c40XOa505a3f19f25843c4b207c3f00">
              <SHORT-NAME>PEUFltIO</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltIO_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUFltIO_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cc9b6XOa505a3f19f25843c4b1cc9b500">
              <SHORT-NAME>PEUHVIntlckClsd</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUHVIntlckClsd_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUHVIntlckClsd_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207d08XOa505a3f19f25843c4b207d0700">
              <SHORT-NAME>PEUInvtrADCCrnt</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrADCCrnt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-3276.7</V>
                        <V>0.1</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrADCCrnt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-3276.7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3276.8</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207d43XOa505a3f19f25843c4b207d4200">
              <SHORT-NAME>PEUInvtrADCCrntV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrADCCrntV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrADCCrntV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207da5XOa505a3f19f25843c4b207da400">
              <SHORT-NAME>PEUInvtrADCVlt</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrADCVlt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>0.1</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrADCVlt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6553.5</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207ddcXOa505a3f19f25843c4b207ddb00">
              <SHORT-NAME>PEUInvtrADCVltV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrADCVltV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrADCVltV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cce8dXOa505a3f19f25843c4b1cce8c00">
              <SHORT-NAME>PEUInvtrATem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrATem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrATem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccec4XOa505a3f19f25843c4b1ccec300">
              <SHORT-NAME>PEUInvtrATemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrATemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrATemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207e3eXOa505a3f19f25843c4b207e3d00">
              <SHORT-NAME>PEUInvtrBDCCrnt</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBDCCrnt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-3276.7</V>
                        <V>0.1</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBDCCrnt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-3276.7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3276.8</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207e79XOa505a3f19f25843c4b207e7800">
              <SHORT-NAME>PEUInvtrBDCCrntV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBDCCrntV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBDCCrntV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207edbXOa505a3f19f25843c4b207eda00">
              <SHORT-NAME>PEUInvtrBDCVlt</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBDCVlt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>0.1</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBDCVlt</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6553.5</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207f12XOa505a3f19f25843c4b207f1100">
              <SHORT-NAME>PEUInvtrBDCVltV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBDCVltV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBDCVltV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccf26XOa505a3f19f25843c4b1ccf2500">
              <SHORT-NAME>PEUInvtrBTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUInvtrBTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccf5dXOa505a3f19f25843c4b1ccf5c00">
              <SHORT-NAME>PEUInvtrBTemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBTemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUInvtrBTemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccfbfXOa505a3f19f25843c4b1ccfbe00">
              <SHORT-NAME>PEUMotACtrlSysFltCodeA</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotACtrlSysFltCodeA</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4.294967295E9</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotACtrlSysFltCodeA</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4.294967295E9</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5565XOa505a3f19f25843c4b1e556400">
              <SHORT-NAME>PEUMotADampTrqCmdd</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotADampTrqCmdd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.96875</V>
                        <V>0.03125</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotADampTrqCmdd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.96875</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1ccff3XOa505a3f19f25843c4b1ccff200">
              <SHORT-NAME>PEUMotAInvtrFltSta</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAInvtrFltSta_0_None</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAInvtrFltSta_1_Critical_HV_Fault</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAInvtrFltSta_2_Critical_Non_HV_Fault</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207f74XOa505a3f19f25843c4b207f7300">
              <SHORT-NAME>PEUMotAMaxToqCapLongTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMaxToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMaxToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207fafXOa505a3f19f25843c4b207fae00">
              <SHORT-NAME>PEUMotAMaxToqCapShtrTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMaxToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMaxToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Na505a3f19f7d0600db2fcfeXNa505a3f19f7d0600db2fcf800">
              <SHORT-NAME>PEUMotAMdAch</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAMdAch_0_None</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAMdAch_1_Torque</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAMdAch_2_Speed</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAMdAch_3_Voltage</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207feaXOa505a3f19f25843c4b207fe900">
              <SHORT-NAME>PEUMotAMinToqCapLongTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMinToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMinToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b208025XOa505a3f19f25843c4b20802400">
              <SHORT-NAME>PEUMotAMinToqCapShtrTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMinToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAMinToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd06cXOa505a3f19f25843c4b1cd06b00">
              <SHORT-NAME>PEUMotARsovrOfstLrnCalSta</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARsovrOfstLrnCalSta_0_Default</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARsovrOfstLrnCalSta_1_Cal_Pass</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARsovrOfstLrnCalSta_2_Cal_Fail</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARsovrOfstLrnCalSta_3_Cal_In_Progress</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd0fcXOa505a3f19f25843c4b1cd0fb00">
              <SHORT-NAME>PEUMotARtrTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotARtrTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>5.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotARtrTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1235.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd137XOa505a3f19f25843c4b1cd13600">
              <SHORT-NAME>PEUMotARtrTemFltPrst</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARtrTemFltPrst_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotARtrTemFltPrst_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e55a0XOa505a3f19f25843c4b1e559f00">
              <SHORT-NAME>PEUMotASpd</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/rpm1</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotASpd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-32768.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotASpd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-32768.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">32767.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b21a32cXOa505a3f19f25843c4b21a32b00">
              <SHORT-NAME>PEUMotASpdBkup</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotASpdBkup</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-32768.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotASpdBkup</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-32768.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">32767.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5639XOa505a3f19f25843c4b1e563800">
              <SHORT-NAME>PEUMotASpdSts</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdSts_0_Speed_Normal</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdSts_1_Speed_Degraded</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdSts_2_Speed_Backup_Source</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdSts_3_Speed_Unusable</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e55d7XOa505a3f19f25843c4b1e55d600">
              <SHORT-NAME>PEUMotASpdV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b21a363XOa505a3f19f25843c4b21a36200">
              <SHORT-NAME>PEUMotASpdVBkup</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdVBkup_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotASpdVBkup_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd199XOa505a3f19f25843c4b1cd19800">
              <SHORT-NAME>PEUMotATem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotATem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotATem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd1d0XOa505a3f19f25843c4b1cd1cf00">
              <SHORT-NAME>PEUMotATemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotATemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotATemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e56c9XOa505a3f19f25843c4b1e56c800">
              <SHORT-NAME>PEUMotAToqAch</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAToqAch</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotAToqAch</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5704XOa505a3f19f25843c4b1e570300">
              <SHORT-NAME>PEUMotAToqAchV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAToqAchV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotAToqAchV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd232XOa505a3f19f25843c4b1cd23100">
              <SHORT-NAME>PEUMotBCtrlSysFltCodeA</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBCtrlSysFltCodeA</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4.294967295E9</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBCtrlSysFltCodeA</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4.294967295E9</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5766XOa505a3f19f25843c4b1e576500">
              <SHORT-NAME>PEUMotBDampTrqCmdd</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBDampTrqCmdd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.96875</V>
                        <V>0.03125</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBDampTrqCmdd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.96875</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd266XOa505a3f19f25843c4b1cd26500">
              <SHORT-NAME>PEUMotBInvtrFltSta</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBInvtrFltSta_0_None</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBInvtrFltSta_1_Critical_HV_Fault</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBInvtrFltSta_2_Critical_Non_HV_Fault</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b208060XOa505a3f19f25843c4b20805f00">
              <SHORT-NAME>PEUMotBMaxToqCapLongTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMaxToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMaxToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20809bXOa505a3f19f25843c4b20809a00">
              <SHORT-NAME>PEUMotBMaxToqCapShtrTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMaxToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMaxToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Na505a3f19f7d0600db2fdb1XNa505a3f19f7d0600db2fdab00">
              <SHORT-NAME>PEUMotBMdAch</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBMdAch_0_None</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBMdAch_1_Torque</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBMdAch_2_Speed</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBMdAch_3_Voltage</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2080d6XOa505a3f19f25843c4b2080d500">
              <SHORT-NAME>PEUMotBMinToqCapLongTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMinToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMinToqCapLongTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b208111XOa505a3f19f25843c4b20811000">
              <SHORT-NAME>PEUMotBMinToqCapShtrTerm</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMinToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4095</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-1023.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBMinToqCapShtrTerm</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-1023.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1024.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd2dfXOa505a3f19f25843c4b1cd2de00">
              <SHORT-NAME>PEUMotBRsovrOfstLrnCalSta</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRsovrOfstLrnCalSta_0_Default</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRsovrOfstLrnCalSta_1_Cal_Pass</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRsovrOfstLrnCalSta_2_Cal_Fail</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRsovrOfstLrnCalSta_3_Cal_In_Progress</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd36fXOa505a3f19f25843c4b1cd36e00">
              <SHORT-NAME>PEUMotBRtrTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBRtrTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>5.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBRtrTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1235.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd3aaXOa505a3f19f25843c4b1cd3a900">
              <SHORT-NAME>PEUMotBRtrTemFltPrst</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRtrTemFltPrst_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBRtrTemFltPrst_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e57a1XOa505a3f19f25843c4b1e57a000">
              <SHORT-NAME>PEUMotBSpd</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBSpd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-32768.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBSpd</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-32768.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">32767.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e57d8XOa505a3f19f25843c4b1e57d700">
              <SHORT-NAME>PEUMotBSpdSts</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdSts_0_Speed_Normal</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdSts_1_Speed_Degraded</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdSts_2_Speed_Backup_Source</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdSts_3_Speed_Unusable</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5868XOa505a3f19f25843c4b1e586700">
              <SHORT-NAME>PEUMotBSpdV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBSpdV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd40cXOa505a3f19f25843c4b1cd40b00">
              <SHORT-NAME>PEUMotBTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd443XOa505a3f19f25843c4b1cd44200">
              <SHORT-NAME>PEUMotBTemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBTemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBTemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e58caXOa505a3f19f25843c4b1e58c900">
              <SHORT-NAME>PEUMotBToqAch</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBToqAch</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2047.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-511.5</V>
                        <V>0.5</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUMotBToqAch</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-511.5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">512.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5905XOa505a3f19f25843c4b1e590400">
              <SHORT-NAME>PEUMotBToqAchV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBToqAchV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUMotBToqAchV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd602XOa505a3f19f25843c4b1cd60100">
              <SHORT-NAME>PEUPwrElecUnitInltCIntTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrElecUnitInltCIntTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrElecUnitInltCIntTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd639XOa505a3f19f25843c4b1cd63800">
              <SHORT-NAME>PEUPwrElecUnitInltCIntTemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrElecUnitInltCIntTemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrElecUnitInltCIntTemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd69bXOa505a3f19f25843c4b1cd69a00">
              <SHORT-NAME>PEUPwrElecUnitOtltCIntTem</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrElecUnitOtltCIntTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>-40.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrElecUnitOtltCIntTem</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">-40.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd6d2XOa505a3f19f25843c4b1cd6d100">
              <SHORT-NAME>PEUPwrElecUnitOtltCIntTemV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrElecUnitOtltCIntTemV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrElecUnitOtltCIntTemV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd4a5XOa505a3f19f25843c4b1cd4a400">
              <SHORT-NAME>PEUPwrEleccsClntFludLvlLow</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsClntFludLvlLow_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsClntFludLvlLow_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd507XOa505a3f19f25843c4b1cd50600">
              <SHORT-NAME>PEUPwrEleccsClntFludLvlLowV</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsClntFludLvlLowV_0_Valid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsClntFludLvlLowV_1_Invalid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd5cbXOa505a3f19f25843c4b1cd5ca00">
              <SHORT-NAME>PEUPwrEleccsCoolngPumpPWMFdbk</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrEleccsCoolngPumpPWMFdbk</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>0.392157</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEUPwrEleccsCoolngPumpPWMFdbk</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">100.000035</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1cd569XOa505a3f19f25843c4b1cd56800">
              <SHORT-NAME>PEUPwrEleccsCoolngPumpPerfDgrade</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsCoolngPumpPerfDgrade_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUPwrEleccsCoolngPumpPerfDgrade_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207b78XOa505a3f19f25843c4b207b7700">
              <SHORT-NAME>PEU_100ms_Group11_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207babXOa505a3f19f25843c4b207baa00">
              <SHORT-NAME>PEU_100ms_Group11_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9096XOa505a3f19f25843c4b2a909500">
              <SHORT-NAME>PEU_100ms_Group11_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9261XOa505a3f19f25843c4b2a926000">
              <SHORT-NAME>PEU_100ms_Group11_Reserved10</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9294XOa505a3f19f25843c4b2a929300">
              <SHORT-NAME>PEU_100ms_Group11_Reserved11</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved11</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved11</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a92c7XOa505a3f19f25843c4b2a92c600">
              <SHORT-NAME>PEU_100ms_Group11_Reserved12</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved12</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved12</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a92faXOa505a3f19f25843c4b2a92f900">
              <SHORT-NAME>PEU_100ms_Group11_Reserved13</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved13</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved13</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a932dXOa505a3f19f25843c4b2a932c00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved14</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved14</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved14</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9360XOa505a3f19f25843c4b2a935f00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved15</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved15</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved15</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9393XOa505a3f19f25843c4b2a939200">
              <SHORT-NAME>PEU_100ms_Group11_Reserved16</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved16</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved16</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a90c9XOa505a3f19f25843c4b2a90c800">
              <SHORT-NAME>PEU_100ms_Group11_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a90fcXOa505a3f19f25843c4b2a90fb00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a912fXOa505a3f19f25843c4b2a912e00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved4</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9162XOa505a3f19f25843c4b2a916100">
              <SHORT-NAME>PEU_100ms_Group11_Reserved5</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9195XOa505a3f19f25843c4b2a919400">
              <SHORT-NAME>PEU_100ms_Group11_Reserved6</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a91c8XOa505a3f19f25843c4b2a91c700">
              <SHORT-NAME>PEU_100ms_Group11_Reserved7</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a91fbXOa505a3f19f25843c4b2a91fa00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved8</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a922eXOa505a3f19f25843c4b2a922d00">
              <SHORT-NAME>PEU_100ms_Group11_Reserved9</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group11_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a7912XOa505a3f19f25843c4b2a791100">
              <SHORT-NAME>PEU_100ms_Group15_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a7945XOa505a3f19f25843c4b2a794400">
              <SHORT-NAME>PEU_100ms_Group15_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8607XOa505a3f19f25843c4b2a860600">
              <SHORT-NAME>PEU_100ms_Group15_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a87d2XOa505a3f19f25843c4b2a87d100">
              <SHORT-NAME>PEU_100ms_Group15_Reserved10</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8805XOa505a3f19f25843c4b2a880400">
              <SHORT-NAME>PEU_100ms_Group15_Reserved11</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved11</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved11</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8838XOa505a3f19f25843c4b2a883700">
              <SHORT-NAME>PEU_100ms_Group15_Reserved12</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved12</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved12</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a886bXOa505a3f19f25843c4b2a886a00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved13</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved13</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved13</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a889eXOa505a3f19f25843c4b2a889d00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved14</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved14</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved14</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a88d1XOa505a3f19f25843c4b2a88d000">
              <SHORT-NAME>PEU_100ms_Group15_Reserved15</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved15</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved15</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8904XOa505a3f19f25843c4b2a890300">
              <SHORT-NAME>PEU_100ms_Group15_Reserved16</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved16</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved16</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8937XOa505a3f19f25843c4b2a893600">
              <SHORT-NAME>PEU_100ms_Group15_Reserved17</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved17</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved17</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a896aXOa505a3f19f25843c4b2a896900">
              <SHORT-NAME>PEU_100ms_Group15_Reserved18</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved18</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved18</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a899dXOa505a3f19f25843c4b2a899c00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved19</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved19</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved19</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a863aXOa505a3f19f25843c4b2a863900">
              <SHORT-NAME>PEU_100ms_Group15_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a89d0XOa505a3f19f25843c4b2a89cf00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved20</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved20</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved20</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8a03XOa505a3f19f25843c4b2a8a0200">
              <SHORT-NAME>PEU_100ms_Group15_Reserved21</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved21</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved21</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8a36XOa505a3f19f25843c4b2a8a3500">
              <SHORT-NAME>PEU_100ms_Group15_Reserved22</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved22</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved22</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8a69XOa505a3f19f25843c4b2a8a6800">
              <SHORT-NAME>PEU_100ms_Group15_Reserved23</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved23</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved23</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8a9cXOa505a3f19f25843c4b2a8a9b00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved24</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved24</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved24</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8acfXOa505a3f19f25843c4b2a8ace00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved25</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved25</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved25</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8b02XOa505a3f19f25843c4b2a8b0100">
              <SHORT-NAME>PEU_100ms_Group15_Reserved26</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved26</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved26</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8b35XOa505a3f19f25843c4b2a8b3400">
              <SHORT-NAME>PEU_100ms_Group15_Reserved27</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved27</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved27</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8b68XOa505a3f19f25843c4b2a8b6700">
              <SHORT-NAME>PEU_100ms_Group15_Reserved28</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved28</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved28</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8b9bXOa505a3f19f25843c4b2a8b9a00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved29</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved29</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved29</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a866dXOa505a3f19f25843c4b2a866c00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8bceXOa505a3f19f25843c4b2a8bcd00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved30</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved30</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved30</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8c01XOa505a3f19f25843c4b2a8c0000">
              <SHORT-NAME>PEU_100ms_Group15_Reserved31</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved31</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved31</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8c34XOa505a3f19f25843c4b2a8c3300">
              <SHORT-NAME>PEU_100ms_Group15_Reserved32</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved32</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved32</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8c67XOa505a3f19f25843c4b2a8c6600">
              <SHORT-NAME>PEU_100ms_Group15_Reserved33</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved33</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved33</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a86a0XOa505a3f19f25843c4b2a869f00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved4</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a86d3XOa505a3f19f25843c4b2a86d200">
              <SHORT-NAME>PEU_100ms_Group15_Reserved5</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8706XOa505a3f19f25843c4b2a870500">
              <SHORT-NAME>PEU_100ms_Group15_Reserved6</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a8739XOa505a3f19f25843c4b2a873800">
              <SHORT-NAME>PEU_100ms_Group15_Reserved7</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a876cXOa505a3f19f25843c4b2a876b00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved8</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a879fXOa505a3f19f25843c4b2a879e00">
              <SHORT-NAME>PEU_100ms_Group15_Reserved9</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_100ms_Group15_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e54ffXOa505a3f19f25843c4b1e54fe00">
              <SHORT-NAME>PEU_10ms_Group25_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1e5532XOa505a3f19f25843c4b1e553100">
              <SHORT-NAME>PEU_10ms_Group25_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9cf0XOa505a3f19f25843c4b2a9cef00">
              <SHORT-NAME>PEU_10ms_Group25_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="N200000119f8c72e8e0676a0XN200000119f8c72e8e06769a00">
              <SHORT-NAME>PEU_10ms_Group25_Reserved147</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved147</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved147</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2a9d56XOa505a3f19f25843c4b2a9d5500">
              <SHORT-NAME>PEU_10ms_Group25_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_10ms_Group25_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b208776XOa505a3f19f25843c4b20877500">
              <SHORT-NAME>PEU_25ms_Group27_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_25ms_Group27_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_25ms_Group27_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2087a9XOa505a3f19f25843c4b2087a800">
              <SHORT-NAME>PEU_25ms_Group27_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_25ms_Group27_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_25ms_Group27_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207ca2XOa505a3f19f25843c4b207ca100">
              <SHORT-NAME>PEU_50ms_Group28_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b207cd5XOa505a3f19f25843c4b207cd400">
              <SHORT-NAME>PEU_50ms_Group28_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2159daXOa505a3f19f25843c4b2159d900">
              <SHORT-NAME>PEU_50ms_Group28_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215ba5XOa505a3f19f25843c4b215ba400">
              <SHORT-NAME>PEU_50ms_Group28_Reserved10</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215a0dXOa505a3f19f25843c4b215a0c00">
              <SHORT-NAME>PEU_50ms_Group28_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215a40XOa505a3f19f25843c4b215a3f00">
              <SHORT-NAME>PEU_50ms_Group28_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215a73XOa505a3f19f25843c4b215a7200">
              <SHORT-NAME>PEU_50ms_Group28_Reserved4</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215aa6XOa505a3f19f25843c4b215aa500">
              <SHORT-NAME>PEU_50ms_Group28_Reserved5</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215ad9XOa505a3f19f25843c4b215ad800">
              <SHORT-NAME>PEU_50ms_Group28_Reserved6</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215b0cXOa505a3f19f25843c4b215b0b00">
              <SHORT-NAME>PEU_50ms_Group28_Reserved7</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215b3fXOa505a3f19f25843c4b215b3e00">
              <SHORT-NAME>PEU_50ms_Group28_Reserved8</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215b72XOa505a3f19f25843c4b215b7100">
              <SHORT-NAME>PEU_50ms_Group28_Reserved9</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_50ms_Group28_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b21456fXOa505a3f19f25843c4b21456e00">
              <SHORT-NAME>PEU_ERAvlbly</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_ERAvlbly_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_ERAvlbly_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b228524XOa505a3f19f25843c4b22852300">
              <SHORT-NAME>PEU_ExtdAvlbly</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAvlbly_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEUAvlbly_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225baaXOa505a3f19f25843c4b225ba900">
              <SHORT-NAME>PEU_NKI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTCANFD_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTCANFD_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTCANFD_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225c51XOa505a3f19f25843c4b225c5000">
              <SHORT-NAME>PEU_NKI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTEXTDCAN_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTEXTDCAN_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTEXTDCAN_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTEXTDCAN_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_PTEXTDCAN_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225cf8XOa505a3f19f25843c4b225cf700">
              <SHORT-NAME>PEU_NKI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_SFCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_SFCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_SFCANFD_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_SFCANFD_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NKI_SFCANFD_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225d9fXOa505a3f19f25843c4b225d9e00">
              <SHORT-NAME>PEU_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225e01XOa505a3f19f25843c4b225e0000">
              <SHORT-NAME>PEU_NM_BSMtoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225e63XOa505a3f19f25843c4b225e6200">
              <SHORT-NAME>PEU_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_BSMtoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225ec5XOa505a3f19f25843c4b225ec400">
              <SHORT-NAME>PEU_NM_NOSSta_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225f27XOa505a3f19f25843c4b225f2600">
              <SHORT-NAME>PEU_NM_NOSSta_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225f89XOa505a3f19f25843c4b225f8800">
              <SHORT-NAME>PEU_NM_NOSSta_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOSSta_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b225febXOa505a3f19f25843c4b225fea00">
              <SHORT-NAME>PEU_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b22604dXOa505a3f19f25843c4b22604c00">
              <SHORT-NAME>PEU_NM_NOStoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2260afXOa505a3f19f25843c4b2260ae00">
              <SHORT-NAME>PEU_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_NOStoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226111XOa505a3f19f25843c4b22611000">
              <SHORT-NAME>PEU_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226173XOa505a3f19f25843c4b22617200">
              <SHORT-NAME>PEU_NM_PBSMtoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2261d5XOa505a3f19f25843c4b2261d400">
              <SHORT-NAME>PEU_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_PBSMtoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226237XOa505a3f19f25843c4b22623600">
              <SHORT-NAME>PEU_NM_RMSSta_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226299XOa505a3f19f25843c4b22629800">
              <SHORT-NAME>PEU_NM_RMSSta_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2262fbXOa505a3f19f25843c4b2262fa00">
              <SHORT-NAME>PEU_NM_RMSSta_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMSSta_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b22635dXOa505a3f19f25843c4b22635c00">
              <SHORT-NAME>PEU_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2263bfXOa505a3f19f25843c4b2263be00">
              <SHORT-NAME>PEU_NM_RMStoNOS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226421XOa505a3f19f25843c4b22642000">
              <SHORT-NAME>PEU_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RMStoNOS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226483XOa505a3f19f25843c4b22648200">
              <SHORT-NAME>PEU_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2264e5XOa505a3f19f25843c4b2264e400">
              <SHORT-NAME>PEU_NM_RSStoNOS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226547XOa505a3f19f25843c4b22654600">
              <SHORT-NAME>PEU_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoNOS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2265a9XOa505a3f19f25843c4b2265a800">
              <SHORT-NAME>PEU_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b22660bXOa505a3f19f25843c4b22660a00">
              <SHORT-NAME>PEU_NM_RSStoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b22666dXOa505a3f19f25843c4b22666c00">
              <SHORT-NAME>PEU_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NM_RSStoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2266cfXOa505a3f19f25843c4b2266ce00">
              <SHORT-NAME>PEU_NOI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_PTCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_PTCANFD_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226731XOa505a3f19f25843c4b22673000">
              <SHORT-NAME>PEU_NOI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_PTEXTDCAN_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_PTEXTDCAN_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226793XOa505a3f19f25843c4b22679200">
              <SHORT-NAME>PEU_NOI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_SFCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NOI_SFCANFD_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2267f5XOa505a3f19f25843c4b2267f400">
              <SHORT-NAME>PEU_NWI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_PTCANFD_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_PTCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b226857XOa505a3f19f25843c4b22685600">
              <SHORT-NAME>PEU_NWI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_PTEXTDCAN_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_PTEXTDCAN_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2268b9XOa505a3f19f25843c4b2268b800">
              <SHORT-NAME>PEU_NWI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_SFCANFD_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_NWI_SFCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2145d1XOa505a3f19f25843c4b2145d000">
              <SHORT-NAME>PEU_PTAvlbly</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_PTAvlbly_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_PTAvlbly_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b228586XOa505a3f19f25843c4b22858500">
              <SHORT-NAME>PEU_SFAvlbly</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_SFAvlbly_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PEU_SFAvlbly_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b221e09XOa505a3f19f25843c4b221e0800">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b221e3cXOa505a3f19f25843c4b221e3b00">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227a37XOa505a3f19f25843c4b227a3600">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227a6aXOa505a3f19f25843c4b227a6900">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227a9dXOa505a3f19f25843c4b227a9c00">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">63.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">63.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227ad0XOa505a3f19f25843c4b227acf00">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved4</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">31.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227b03XOa505a3f19f25843c4b227b0200">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved5</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227b36XOa505a3f19f25843c4b227b3500">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved6</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227b69XOa505a3f19f25843c4b227b6800">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved7</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227b9cXOa505a3f19f25843c4b227b9b00">
              <SHORT-NAME>PEU_ZONE_100ms_Group03_Reserved8</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_100ms_Group03_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b221fa1XOa505a3f19f25843c4b221fa000">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b221fd4XOa505a3f19f25843c4b221fd300">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbe1fXOa505a3f19f25843c4b2dbe1e00">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbfeaXOa505a3f19f25843c4b2dbfe900">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved10</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved10</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbe52XOa505a3f19f25843c4b2dbe5100">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbe85XOa505a3f19f25843c4b2dbe8400">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved3</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved3</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbeb8XOa505a3f19f25843c4b2dbeb700">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved4</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved4</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbeebXOa505a3f19f25843c4b2dbeea00">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved5</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved5</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbf1eXOa505a3f19f25843c4b2dbf1d00">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved6</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved6</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbf51XOa505a3f19f25843c4b2dbf5000">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved7</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved7</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbf84XOa505a3f19f25843c4b2dbf8300">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved8</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved8</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2dbfb7XOa505a3f19f25843c4b2dbfb600">
              <SHORT-NAME>PEU_ZONE_10ms_Group02_Reserved9</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_10ms_Group02_Reserved9</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b222461XOa505a3f19f25843c4b22246000">
              <SHORT-NAME>PEU_ZONE_5ms_Group01_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b222494XOa505a3f19f25843c4b22249300">
              <SHORT-NAME>PEU_ZONE_5ms_Group01_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227d34XOa505a3f19f25843c4b227d3300">
              <SHORT-NAME>PEU_ZONE_5ms_Group01_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b227d67XOa505a3f19f25843c4b227d6600">
              <SHORT-NAME>PEU_ZONE_5ms_Group01_Reserved2</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PEU_ZONE_5ms_Group01_Reserved2</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b209494XOa505a3f19f25843c4b20949300">
              <SHORT-NAME>PICM_10ms_Group10_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2094c7XOa505a3f19f25843c4b2094c600">
              <SHORT-NAME>PICM_10ms_Group10_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b215bd8XOa505a3f19f25843c4b215bd700">
              <SHORT-NAME>PICM_10ms_Group10_Reserved1</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_10ms_Group10_Reserved1</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ef20XOa505a3f19f25843c4b20ef1f00">
              <SHORT-NAME>PICM_NKI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTCANFD_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTCANFD_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTCANFD_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e62aXOa505a3f19f25843c4b20e62900">
              <SHORT-NAME>PICM_NKI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTEXTDCAN_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTEXTDCAN_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTEXTDCAN_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTEXTDCAN_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_PTEXTDCAN_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20eaa5XOa505a3f19f25843c4b20eaa400">
              <SHORT-NAME>PICM_NKI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_SFCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_SFCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_SFCANFD_2_ThermalFaultActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_SFCANFD_4_Refuel</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">16</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">16</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NKI_SFCANFD_16_HVBulid</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e256XOa505a3f19f25843c4b20e25500">
              <SHORT-NAME>PICM_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e6d1XOa505a3f19f25843c4b20e6d000">
              <SHORT-NAME>PICM_NM_BSMtoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20eb4cXOa505a3f19f25843c4b20eb4b00">
              <SHORT-NAME>PICM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_BSMtoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e2b8XOa505a3f19f25843c4b20e2b700">
              <SHORT-NAME>PICM_NM_NOSSta_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e733XOa505a3f19f25843c4b20e73200">
              <SHORT-NAME>PICM_NM_NOSSta_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ebaeXOa505a3f19f25843c4b20ebad00">
              <SHORT-NAME>PICM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOSSta_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e31aXOa505a3f19f25843c4b20e31900">
              <SHORT-NAME>PICM_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e795XOa505a3f19f25843c4b20e79400">
              <SHORT-NAME>PICM_NM_NOStoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ec10XOa505a3f19f25843c4b20ec0f00">
              <SHORT-NAME>PICM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_NOStoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e37cXOa505a3f19f25843c4b20e37b00">
              <SHORT-NAME>PICM_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e7f7XOa505a3f19f25843c4b20e7f600">
              <SHORT-NAME>PICM_NM_PBSMtoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ec72XOa505a3f19f25843c4b20ec7100">
              <SHORT-NAME>PICM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_PBSMtoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e3deXOa505a3f19f25843c4b20e3dd00">
              <SHORT-NAME>PICM_NM_RMSSta_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e859XOa505a3f19f25843c4b20e85800">
              <SHORT-NAME>PICM_NM_RMSSta_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ecd4XOa505a3f19f25843c4b20ecd300">
              <SHORT-NAME>PICM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMSSta_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e440XOa505a3f19f25843c4b20e43f00">
              <SHORT-NAME>PICM_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e8bbXOa505a3f19f25843c4b20e8ba00">
              <SHORT-NAME>PICM_NM_RMStoNOS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ed36XOa505a3f19f25843c4b20ed3500">
              <SHORT-NAME>PICM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RMStoNOS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e4a2XOa505a3f19f25843c4b20e4a100">
              <SHORT-NAME>PICM_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e91dXOa505a3f19f25843c4b20e91c00">
              <SHORT-NAME>PICM_NM_RSStoNOS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ed98XOa505a3f19f25843c4b20ed9700">
              <SHORT-NAME>PICM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoNOS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e504XOa505a3f19f25843c4b20e50300">
              <SHORT-NAME>PICM_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_PTCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_PTCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e97fXOa505a3f19f25843c4b20e97e00">
              <SHORT-NAME>PICM_NM_RSStoRMS_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_PTEXTDCAN_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_PTEXTDCAN_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20edfaXOa505a3f19f25843c4b20edf900">
              <SHORT-NAME>PICM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_SFCANFD_0_False</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NM_RSStoRMS_SFCANFD_1_True</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e566XOa505a3f19f25843c4b20e56500">
              <SHORT-NAME>PICM_NOI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_PTCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_PTCANFD_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e9e1XOa505a3f19f25843c4b20e9e000">
              <SHORT-NAME>PICM_NOI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_PTEXTDCAN_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_PTEXTDCAN_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ee5cXOa505a3f19f25843c4b20ee5b00">
              <SHORT-NAME>PICM_NOI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_SFCANFD_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">65535</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">65535</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NOI_SFCANFD_65535_AllNetworkOperationActive</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20e5c8XOa505a3f19f25843c4b20e5c700">
              <SHORT-NAME>PICM_NWI_PTCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_PTCANFD_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_PTCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20ea43XOa505a3f19f25843c4b20ea4200">
              <SHORT-NAME>PICM_NWI_PTEXTDCAN</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_PTEXTDCAN_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_PTEXTDCAN_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b20eebeXOa505a3f19f25843c4b20eebd00">
              <SHORT-NAME>PICM_NWI_SFCANFD</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_SFCANFD_0_NoWakeNetworkSource</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>PICM_NWI_SFCANFD_1_PowerModeIsNonOFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b205a42XOa505a3f19f25843c4b205a4100">
              <SHORT-NAME>PICM_VCU_10ms_Group03_CRC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_CRC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b205a75XOa505a3f19f25843c4b205a7400">
              <SHORT-NAME>PICM_VCU_10ms_Group03_RC</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_RC</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c6603XOa505a3f19f25843c4b2c660200">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved109</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved109</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">63.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved109</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">63.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c6636XOa505a3f19f25843c4b2c663500">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved119</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved119</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved119</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c6669XOa505a3f19f25843c4b2c666800">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved127</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved127</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved127</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c669cXOa505a3f19f25843c4b2c669b00">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved135</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved135</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved135</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c66cfXOa505a3f19f25843c4b2c66ce00">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved143</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved143</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved143</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c6702XOa505a3f19f25843c4b2c670100">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved151</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved151</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved151</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2c6735XOa505a3f19f25843c4b2c673400">
              <SHORT-NAME>PICM_VCU_10ms_Group03_Reserved159</SHORT-NAME>
              <CATEGORY>LINEAR</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved159</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>PICM_VCU_10ms_Group03_Reserved159</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-PHYS-TO-INTERNAL>
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Na505a3f19f3a1b41323c18eXNa505a3f19f3a1b41323c18800">
              <SHORT-NAME>PICUAlgFlag</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
