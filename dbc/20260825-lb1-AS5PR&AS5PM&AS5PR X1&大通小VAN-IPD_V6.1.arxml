                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b26f6a8XOa505a3f19f25843c4b26f6a700">
              <SHORT-NAME>DoorFLSpeLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorFLSpeLampColorCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2706e8XOa505a3f19f25843c4b2706e700">
              <SHORT-NAME>DoorFLSpeLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b26f646XOa505a3f19f25843c4b26f64500">
              <SHORT-NAME>DoorFLSpeLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFLSpeLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27b11aXOa505a3f19f25843c4b27b11900">
              <SHORT-NAME>DoorFRLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27a2d5XOa505a3f19f25843c4b27a2d400">
              <SHORT-NAME>DoorFRLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorFLLampBrtnsCmd_RHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27a27eXOa505a3f19f25843c4b27a27d00">
              <SHORT-NAME>DoorFRLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorFLLampColorCmd_RHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27b2beXOa505a3f19f25843c4b27b2bd00">
              <SHORT-NAME>DoorFRLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27a21cXOa505a3f19f25843c4b27a21b00">
              <SHORT-NAME>DoorFRLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2749deXOa505a3f19f25843c4b2749dd00">
              <SHORT-NAME>DoorFRSpeLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b273b99XOa505a3f19f25843c4b273b9800">
              <SHORT-NAME>DoorFRSpeLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorFRSpeLampBrtnsCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b273b42XOa505a3f19f25843c4b273b4100">
              <SHORT-NAME>DoorFRSpeLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorFRSpeLampColorCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b274b82XOa505a3f19f25843c4b274b8100">
              <SHORT-NAME>DoorFRSpeLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b273ae0XOa505a3f19f25843c4b273adf00">
              <SHORT-NAME>DoorFRSpeLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorFRSpeLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b1c76fdXOa505a3f19f25843c4b1c76fc00">
              <SHORT-NAME>DoorLckCtrlReq</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_0_NoRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_1_LockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_2_SuperLockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_3_UnlockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_5_SuperUnlockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_4_SPEUnlockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorLckCtrlReq_6_SuperSPEUnlockRequest</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b279fe8XOa505a3f19f25843c4b279fe700">
              <SHORT-NAME>DoorRLLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2791a3XOa505a3f19f25843c4b2791a200">
              <SHORT-NAME>DoorRLLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLLampBrtnsCmd_LHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27914cXOa505a3f19f25843c4b27914b00">
              <SHORT-NAME>DoorRLLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLLampColorCmd_LHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27a18cXOa505a3f19f25843c4b27a18b00">
              <SHORT-NAME>DoorRLLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2790eaXOa505a3f19f25843c4b2790e900">
              <SHORT-NAME>DoorRLLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d403aXOa505a3f19f25843c4b2d403900">
              <SHORT-NAME>DoorRLSpeLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d31f5XOa505a3f19f25843c4b2d31f400">
              <SHORT-NAME>DoorRLSpeLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLSpeLampBrtnsCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d319eXOa505a3f19f25843c4b2d319d00">
              <SHORT-NAME>DoorRLSpeLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLSpeLampColorCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d41deXOa505a3f19f25843c4b2d41dd00">
              <SHORT-NAME>DoorRLSpeLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d313cXOa505a3f19f25843c4b2d313b00">
              <SHORT-NAME>DoorRLSpeLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRLSpeLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27c24cXOa505a3f19f25843c4b27c24b00">
              <SHORT-NAME>DoorRRLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27b407XOa505a3f19f25843c4b27b40600">
              <SHORT-NAME>DoorRRLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLLampBrtnsCmd_RHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">133</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_133_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">134</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">134</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_134_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">135</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">135</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_135_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">136</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">136</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_136_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">137</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">137</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_137_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">138</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">138</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_138_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">139</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">139</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_139_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">140</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">140</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_140_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">141</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">141</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_141_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">142</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">142</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_142_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">143</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">143</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_143_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">144</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">144</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_144_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">145</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">145</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_145_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">146</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">146</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_146_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">147</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">147</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_147_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">148</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">148</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_148_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">149</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">149</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_149_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">150</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">150</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_150_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">151</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">151</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_151_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">152</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">152</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_152_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">153</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">153</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_153_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">154</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">154</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_154_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">155</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">155</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_155_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">156</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">156</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_156_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">157</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">157</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_157_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">158</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">158</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_158_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">159</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">159</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_159_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">160</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">160</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_160_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">161</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">161</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_161_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">162</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">162</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_162_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">163</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">163</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_163_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">164</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">164</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_164_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">165</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">165</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_165_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">166</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">166</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_166_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">167</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">167</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_167_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">168</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">168</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_168_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">169</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">169</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_169_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">170</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">170</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_170_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">171</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">171</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_171_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">172</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">172</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_172_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">173</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">173</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_173_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">174</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">174</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_174_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">175</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">175</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_175_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">176</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">176</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_176_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">177</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">177</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_177_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">178</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">178</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_178_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">179</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">179</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_179_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">180</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">180</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_180_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">181</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">181</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_181_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">182</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">182</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_182_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">183</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">183</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_183_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">184</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">184</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_184_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">185</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">185</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_185_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">186</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">186</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_186_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">187</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">187</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_187_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">188</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">188</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_188_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">189</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">189</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_189_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">190</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">190</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_190_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">191</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">191</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_191_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">192</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">192</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_192_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">193</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">193</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_193_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">194</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">194</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_194_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">195</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">195</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_195_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">196</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">196</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_196_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">197</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">197</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_197_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">198</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">198</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_198_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">199</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">199</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_199_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">200</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">200</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_200_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">201</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">201</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_201_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">202</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">202</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_202_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">203</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">203</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_203_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">204</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">204</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_204_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">205</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">205</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_205_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">206</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">206</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_206_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">207</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">207</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_207_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">208</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">208</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_208_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">209</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">209</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_209_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">210</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">210</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_210_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">211</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">211</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_211_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">212</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">212</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_212_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">213</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">213</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_213_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">214</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">214</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_214_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">215</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">215</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_215_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">216</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">216</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_216_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">217</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">217</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_217_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">218</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">218</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_218_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">219</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">219</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_219_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">220</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">220</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_220_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">221</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">221</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_221_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">222</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">222</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_222_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">223</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">223</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_223_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">224</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">224</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_224_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">225</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">225</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_225_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">226</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">226</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_226_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">227</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">227</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_227_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">228</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">228</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_228_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">229</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">229</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_229_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">230</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">230</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_230_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">231</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">231</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_231_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">232</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">232</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_232_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">233</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">233</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_233_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">234</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">234</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_234_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">235</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">235</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_235_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">236</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">236</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_236_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">237</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">237</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_237_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">238</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">238</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_238_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">239</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">239</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_239_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">240</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">240</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_240_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">241</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">241</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_241_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">242</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">242</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_242_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">243</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">243</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_243_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">244</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">244</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_244_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">245</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">245</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_245_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">246</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">246</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_246_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">247</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">247</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_247_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">248</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">248</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_248_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">249</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">249</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_249_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">250</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">250</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_250_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">251</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">251</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_251_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">252</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">252</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_252_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">253</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">253</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_253_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">254</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">254</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_254_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">255</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampBrtnsCmd_l_255_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27b3b0XOa505a3f19f25843c4b27b3af00">
              <SHORT-NAME>DoorRRLampColorCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRLLampColorCmd_RHZCU_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampColorCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27c3f0XOa505a3f19f25843c4b27c3ef00">
              <SHORT-NAME>DoorRRLampFadeSpdCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampFadeSpdCmd_l_0_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampFadeSpdCmd_l_1_100ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampFadeSpdCmd_l_2_500ms</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampFadeSpdCmd_l_3_Speed3</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b27b34eXOa505a3f19f25843c4b27b34d00">
              <SHORT-NAME>DoorRRLampOnOff_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampOnOff_l_0_OFF</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRLampOnOff_l_1_ON</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d516cXOa505a3f19f25843c4b2d516b00">
              <SHORT-NAME>DoorRRSpeLampBrthngCmd_l</SHORT-NAME>
              <CATEGORY>TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/null</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">1</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">1</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_1_0_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">2</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">2</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_2_1s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">3</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">3</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_3_2s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">4</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">4</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_4_3s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">5</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">5</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_5_4s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">6</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">6</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_6_5s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">7</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">7</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_7_6s</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">8</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">8</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_8_1s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">9</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">9</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_9_2s_1Percent_to_setting_brightess</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">10</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">10</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_10_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">11</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">11</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_11_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">12</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">12</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_12_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">13</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">13</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_13_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">14</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">14</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_14_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">15</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">15</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrthngCmd_l_15_reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                </COMPU-SCALES>
              </COMPU-INTERNAL-TO-PHYS>
              <COMPU-PHYS-TO-INTERNAL />
            </COMPU-METHOD>
            <COMPU-METHOD UUID="Oa505a3f19f25843c4b2d4327XOa505a3f19f25843c4b2d432600">
              <SHORT-NAME>DoorRRSpeLampBrtnsCmd_l</SHORT-NAME>
              <CATEGORY>SCALE_LINEAR_AND_TEXTTABLE</CATEGORY>
              <UNIT-REF DEST="UNIT">/DataTypes/Units/X_</UNIT-REF>
              <COMPU-INTERNAL-TO-PHYS>
                <COMPU-SCALES>
                  <COMPU-SCALE>
                    <SHORT-LABEL>DoorRRSpeLampBrtnsCmd_l</SHORT-LABEL>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0.0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">255.0</UPPER-LIMIT>
                    <COMPU-RATIONAL-COEFFS>
                      <COMPU-NUMERATOR>
                        <V>0.0</V>
                        <V>1.0</V>
                      </COMPU-NUMERATOR>
                      <COMPU-DENOMINATOR>
                        <V>1</V>
                      </COMPU-DENOMINATOR>
                    </COMPU-RATIONAL-COEFFS>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">0</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">0</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_0_No_Request</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">101</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">101</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_101_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">102</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">102</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_102_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">103</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">103</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_103_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">104</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">104</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_104_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">105</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">105</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_105_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">106</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">106</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_106_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">107</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">107</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_107_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">108</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">108</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_108_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">109</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">109</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_109_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">110</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">110</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_110_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">111</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">111</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_111_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">112</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">112</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_112_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">113</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">113</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_113_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">114</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">114</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_114_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">115</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">115</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_115_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">116</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">116</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_116_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">117</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">117</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_117_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">118</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">118</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_118_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">119</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">119</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_119_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">120</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">120</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_120_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">121</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">121</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_121_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">122</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">122</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_122_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">123</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">123</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_123_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">124</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">124</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_124_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">125</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">125</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_125_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">126</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">126</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_126_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">127</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">127</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_127_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">128</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">128</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_128_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">129</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">129</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_129_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">130</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">130</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_130_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">131</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">131</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_131_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">132</LOWER-LIMIT>
                    <UPPER-LIMIT INTERVAL-TYPE="CLOSED">132</UPPER-LIMIT>
                    <COMPU-CONST>
                      <VT>DoorRRSpeLampBrtnsCmd_l_132_Reserved</VT>
                    </COMPU-CONST>
                  </COMPU-SCALE>
                  <COMPU-SCALE>
                    <LOWER-LIMIT INTERVAL-TYPE="CLOSED">133</LOWER-LIMIT>
