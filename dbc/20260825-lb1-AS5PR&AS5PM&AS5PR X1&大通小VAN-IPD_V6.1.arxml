                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group13_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group13_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group13_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3252400">
                          <SHORT-NAME>IAM_ZONE_100ms_PDU34</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_PDU34_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU34</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Hdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group34_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Pdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Vdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e323ef00">
                          <SHORT-NAME>IAM_ZONE_100ms_PDU35</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_PDU35_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU35</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/GNSSF9HCounter_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/GNSSUTCTime_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group35_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group35_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group35_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3245300">
                          <SHORT-NAME>IAM_ZONE_100ms_PDU40</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_PDU40_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU40</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AltitudeRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HeadingRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group40_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group40_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group40_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group40_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3386700">
                          <SHORT-NAME>IAM_ZONE_100ms_PDU56</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_PDU56_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU56</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_Group56_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_Group56_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_Group56_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_Group56_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_GNSS_Signal_Status_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LatitudeRTK_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e33bb600">
                          <SHORT-NAME>IAM_ZONE_100ms_PDU57</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_100ms_PDU57_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU57</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group57_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group57_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group57_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_Group57_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LongitudeRTK_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b97a900">
                          <SHORT-NAME>ICBAD_100ms_PDU25</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU25_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU25</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved135</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved143</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved151</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved159</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved167</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved175</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved183</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved191</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved87</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group25_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MemPkngSlntPtrlEnbSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MemPkngSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PEBSysFltSts_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fa900">
                          <SHORT-NAME>ICBAD_100ms_PDU27</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU27_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU27</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTSwSts_FCTSwSts_FCTSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTSysFltSts_FCTSysFltSts_FCTSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWSnstvtLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWrnngSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LFCTWrnng_LFCTWrnng_LFCTWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFCTWrnng_RFCTWrnng_RFCTWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f4453ac00">
                          <SHORT-NAME>ICBAD_100ms_PDU29</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU29_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU29</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngDsp_AIParkngDsp_AIParkngDsp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIPilotIntervQuit_AIPilotIntervQuit_AIPilotIntervQuit</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b97bf00">
                          <SHORT-NAME>ICBAD_100ms_PDU31</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU31_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU31</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASpdMdSwSts_APASpdMdSwSts_APASpdMdSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngInPrgs_ParkngInPrgs_ParkngInPrgs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngNCPAvlSts_ParkngNCPAvlSts_ParkngNCPAvlSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcLghtFuctionSwSts_TrfcLghtFuctionSwSts_TrfcLghtFuctionSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdForbidDist_TrfcMrgdForbidDist_TrfcMrgdForbidDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdForbidSign_TrfcMrgdForbidSign_TrfcMrgdForbidSign</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdInfoSignDist_TrfcMrgdInfoSignDist_TrfcMrgdInfoSignDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdInfoSign_TrfcMrgdInfoSign_TrfcMrgdInfoSign</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdWrnngSignDist_TrfcMrgdWrnngSignDist_TrfcMrgdWrnngSignDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcMrgdWrnngSign_TrfcMrgdWrnngSign_TrfcMrgdWrnngSign</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b989f00">
                          <SHORT-NAME>ICBAD_100ms_PDU34</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU34_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU34</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoMainBeamLghtReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DistSinceTrgtCamr_DistSinceTrgtCamr_DistSinceTrgtCamr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdAstCndStsCamr_SpdAstCndStsCamr_SpdAstCndStsCamr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtMdResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrgtCndSpdReqCamr_TrgtCndSpdReqCamr_TrgtCndSpdReqCamr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92cc00">
                          <SHORT-NAME>ICBAD_100ms_PDU36</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU36_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU36</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDMCUTemp_IPDMCUTemp_IPDMCUTemp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDStsResp_IPDStsResp_IPDStsResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_VehLckCtrlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarwSpcAstBtnSts_NarwSpcAstBtnSts_NarwSpcAstBtnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfGreenLghtActn_TrfGreenLghtActn_TrfGreenLghtActn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b954000">
                          <SHORT-NAME>ICBAD_100ms_PDU37</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU37_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU37</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngMsgReq_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngSetResp_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngSwDspCmd_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DILampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HzrdLampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_CRC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_RC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_Group37_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b98aa00">
                          <SHORT-NAME>ICBAD_100ms_PDU38</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU38_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU38</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ELKDspCmd_ELKDspCmd_ELKDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ELKSysFltSts_ELKSysFltSts_ELKSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MemParkngBtnRcnm_MemParkngBtnRcnm_MemParkngBtnRcnm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdSta_NrwroadFwdSta_NrwroadFwdSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadsltSta_NrwroadsltSta_NrwroadsltSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92d700">
                          <SHORT-NAME>ICBAD_100ms_PDU39</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU39_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU39</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarrowRoadBackwardSts_NarrowRoadBackwardSts_NarrowRoadBackwardSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarrowRoadForwardSts_NarrowRoadForwardSts_NarrowRoadForwardSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcLghtStSp_TrfcLghtStSp_TrfcLghtStSp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b952a00">
                          <SHORT-NAME>ICBAD_100ms_PDU44</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_100ms_PDU44_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU44</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngEPAMdsts_AIParkngEPAMdsts_AIParkngEPAMdsts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_D2DPriETClanSwReqResps</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/D2DSwReqResps_D2DSwReqResps_D2DSwReqResps</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTBSysFltSts_FCTBSysFltSts_FCTBSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f6049f81f2572a00">
                          <SHORT-NAME>ICBAD_20ms_PDU05</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU05_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU05</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APACrpSpdReqVal_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APARevrDrgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAToqReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APATotWhlToqReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAVCUReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group05_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b953500">
                          <SHORT-NAME>ICBAD_20ms_PDU07</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU07_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCAccReqSts_CH</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCAccReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCGoReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSdslReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIPkgAPASCSAcclReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAEPBOPReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAEPBOPReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASCSAcclReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysEmgcBrkReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysEmgcBrkReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysFlrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysFlrStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysMdReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysMdReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysSCSDrvOffReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysSCSDrvOffReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysSCSSdslReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysSCSSdslReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group07</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group07_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group07_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group07_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b990500">
                          <SHORT-NAME>ICBAD_20ms_PDU08</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU08_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU08</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCObjDet_ACCObjDet_ACCObjDet</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/D2DSysSts_D2DSysSts_D2DSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b958300">
                          <SHORT-NAME>ICBAD_20ms_PDU09</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU09_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU09</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_CRC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_RC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group09_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NSABacSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NSADisFucSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NSAForSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NSAReqAVMDis_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b982300">
                          <SHORT-NAME>ICBAD_20ms_PDU12</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU12_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group12_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a03148f4f31c41a00">
                          <SHORT-NAME>ICBAD_20ms_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU13_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APACmdEPSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASCUReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASCUReqStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAShifterPosReqd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAShifterPosReqdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APATrgtEPSStrgWhlAng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group13_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8f9300">
                          <SHORT-NAME>ICBAD_20ms_PDU46</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU46_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBBrkJerkLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqToqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBDclReqVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBHydBrkAstLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBPrflReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group46</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group46_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group46_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group46_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group46_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8f9e00">
                          <SHORT-NAME>ICBAD_20ms_PDU48</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_20ms_PDU48_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU48</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_Group48_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWLKALVsulznReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWLKARVsulznReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWLKAVbnLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b96ac00">
                          <SHORT-NAME>ICBAD_50ms_PDU17</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_50ms_PDU17_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_50ms_PDU17</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLObsRng_FLObsRng_FLObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSObsRng_FLSObsRng_FLSObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSideObsRng_FLSideObsRng_FLSideObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRObsRng_FRObsRng_FRObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSObsRng_FRSObsRng_FRSObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSideObsRng_FRSideObsRng_FRSideObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtMidLObsRng_FrtMidLObsRng_FrtMidLObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtMidRObsRng_FrtMidRObsRng_FrtMidRObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtObsDist_FrtObsDist_FrtObsDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtPDCAudWrnng_FrtPDCAudWrnng_FrtPDCAudWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PDCSysSts_PDCSysSts_PDCSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLObsRng_RLObsRng_RLObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLSObsRng_RLSObsRng_RLSObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLSideObsRng_RLSideObsRng_RLSideObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRObsRng_RRObsRng_RRObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRSObsRng_RRSObsRng_RRSObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRSideObsRng_RRSideObsRng_RRSideObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrMidLObsRng_RrMidLObsRng_RrMidLObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrMidRObsRng_RrMidRObsRng_RrMidRObsRng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrObsDist_RrObsDist_RrObsDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrPDCAudWrnng_RrPDCAudWrnng_RrPDCAudWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92e200">
                          <SHORT-NAME>ICBAD_SecOCComKeyResp_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_SecOCComKeyResp_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCComKeyResp_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDTripCntResetResp_IPDTripCntResetResp_IPDTripCntResetResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92ed00">
                          <SHORT-NAME>ICBAD_SecOCLog_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_SecOCLog_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCLog_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDAlgFlag_IPDAlgFlag_IPDAlgFlag</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDDataId_IPDDataId_IPDDataId</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDErrorCount_IPDErrorCount_IPDErrorCount</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDFailedReason_IPDFailedReason_IPDFailedReason</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDKeyStatus_IPDKeyStatus_IPDKeyStatus</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDResetCnt_IPDResetCnt_IPDResetCnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDTripCnt_IPDTripCnt_IPDTripCnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDTripNvmTag_IPDTripNvmTag_IPDTripNvmTag</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b942d00">
                          <SHORT-NAME>ICBAD_ZONE_20ms_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_20ms_PDU13_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LKASysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LKASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TJAICASysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TJAICASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b931900">
                          <SHORT-NAME>ICBVC_1000ms_PDU50</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_1000ms_PDU50_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_1000ms_PDU50</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DistToTrfcJamNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MnvrngPntDistNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MnvrngPntTypNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtPathRngNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcJamRngNav</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e32d0400">
                          <SHORT-NAME>ICBVC_100ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ClstrDspdVehSpd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DspMeasmtSys_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved21</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved72</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved80</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved84</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group01_Reserved92</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MdOfPwrMd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PDCSwReq_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PwrMdExtrCtrlAvlbl_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fb400">
                          <SHORT-NAME>ICBVC_100ms_PDU17</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU17_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU17</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AVMSt_AVMSt_AVMSt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RstrFctryDeftsReq_RstrFctryDeftsReq_RstrFctryDeftsReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92f800">
                          <SHORT-NAME>ICBVC_100ms_PDU25</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU25_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU25</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavCndSpdLmtVal_NavCndSpdLmtVal_NavCndSpdLmtVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavCrntRoadTyp_NavCrntRoadTyp_NavCrntRoadTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_NavDistFromFrtEleccEye</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavNewIconDist_NavNewIconDist_NavNewIconDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavNextRampOffset_NavNextRampOffset_NavNextRampOffset</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavSpdLmtTyp_NavSpdLmtTyp_NavSpdLmtTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavSpdLmtValSts_NavSpdLmtValSts_NavSpdLmtValSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavSpdLmtValUnit_NavSpdLmtValUnit_NavSpdLmtValUnit</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavSpdLmtVal_NavSpdLmtVal_NavSpdLmtVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b930e00">
                          <SHORT-NAME>ICBVC_100ms_PDU257</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU257_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU257</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngEPAMdsw_AIParkngEPAMdsw_AIParkngEPAMdsw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngReq_ZXD_AIParkngReq_ZXD_AIParkngReq_ZXD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAOneKeyParkSwReq_APAOneKeyParkSwReq_APAOneKeyParkSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_APAParkInOffsetTypeReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASWReq_APASWReq_APASWReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngSetReq_AutoLaneChngSetReq_AutoLaneChngSetReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngSwReq_AutoLaneChngSwReq_AutoLaneChngSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngVcCmd_AutoLaneChngVcCmd_AutoLaneChngVcCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/D2DPriETClanSwReq_D2DPriETClanSwReq_D2DPriETClanSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/D2DSwReq_D2DSwReq_D2DSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSAdoWrnngReq_ESSAdoWrnngReq_ESSAdoWrnngReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSswReq_ESSswReq_ESSswReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LCRSwReq_LCRSwReq_LCRSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAETCSetSwReq_NOAETCSetSwReq_NOAETCSetSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOALaneSetSwReq_NOALaneSetSwReq_NOALaneSetSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAQukChgSwReq_NOAQukChgSwReq_NOAQukChgSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAReportSetSwReq_NOAReportSetSwReq_NOAReportSetSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPCitySwReq_NOPCitySwReq_NOPCitySwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPSwReq_NOPSwReq_NOPSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarRoVslAssQuit_NarRoVslAssQuit_NarRoVslAssQuit</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarRoVslAssSwReq_NarRoVslAssSwReq_NarRoVslAssSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_NrwroadBwdAssSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PEBSwReq_PEBSwReq_PEBSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngDirSw_ParkngDirSw_ParkngDirSw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFWrnngMdReq_SLIFWrnngMdReq_SLIFWrnngMdReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b985000">
                          <SHORT-NAME>ICBVC_100ms_PDU27</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU27_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU27</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AVMDspReq_AVMDspReq_AVMDspReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b930300">
                          <SHORT-NAME>ICBVC_100ms_PDU31</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU31_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU31</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngSpdsw_AIParkngSpdsw_AIParkngSpdsw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MemPkngSwReq_MemPkngSwReq_MemPkngSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdCtlReq_NrwroadFwdCtlReq_NrwroadFwdCtlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdReq_NrwroadFwdReq_NrwroadFwdReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadsltReq_NrwroadsltReq_NrwroadsltReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fbf00">
                          <SHORT-NAME>ICBVC_100ms_PDU35</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU35_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU35</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AEBSwReq_AEBSwReq_AEBSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BSDSelReq_BSDSelReq_BSDSelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DOWSelReq_DOWSelReq_DOWSelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ELKSwReq_ELKSwReq_ELKSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWSnstvtLvlReq_FCWSnstvtLvlReq_FCWSnstvtLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCWSwReq_FCWSwReq_FCWSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LCASelReq_LCASelReq_LCASelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWAdoWrnngReq_LDWAdoWrnngReq_LDWAdoWrnngReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_LDWLKAHptWrnngReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWLKASwReq_LDWLKASwReq_LDWLKASwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDWSnstvtLvlReq_LDWSnstvtLvlReq_LDWSnstvtLvlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarwSpcAstSwReq_NarwSpcAstSwReq_NarwSpcAstSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RCTSysSelReq_RCTSysSelReq_RCTSysSelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RCWSelReq_RCWSelReq_RCWSelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RDASwReq_RDASwReq_RDASwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrfcLghtFuctionSwReq_TrfcLghtFuctionSwReq_TrfcLghtFuctionSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b95f100">
                          <SHORT-NAME>ICBVC_100ms_PDU47</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU47_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU47</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FOTAStatus</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FOTAStatusValid</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FOTATarget</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FOTATargetValid</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b98b500">
                          <SHORT-NAME>ICBVC_100ms_PDU48</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU48_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU48</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFUpdtIndReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b916100">
                          <SHORT-NAME>ICBVC_100ms_PDU80</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_100ms_PDU80_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU80</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtPsngAirbagSwStsReqV_Sfty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtPsngAirbagSwStsReq_Sfty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_Group80_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehDrvngMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehLdShedLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehOdo</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehOdoV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b942200">
                          <SHORT-NAME>ICBVC_200ms_PDU50</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_PDU50_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU50</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshDay_VehTiPblshDay_VehTiPblshDay</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshHr_VehTiPblshHr_VehTiPblshHr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshMins_VehTiPblshMins_VehTiPblshMins</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshMth_VehTiPblshMth_VehTiPblshMth</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshSec_VehTiPblshSec_VehTiPblshSec</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehTiPblshYear_VehTiPblshYear_VehTiPblshYear</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b97e100">
                          <SHORT-NAME>ICBVC_200ms_PDU79</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_200ms_PDU79_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU79</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ClstrDspdAirbagWrnng</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EPTNotReadyReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_Group79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_Group79_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_Group79_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_Group79_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_Group79_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OdoPriyPrcs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OdoPriyPrcsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrlrMdSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b941700">
                          <SHORT-NAME>ICBVC_20ms_PDU00</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_PDU00_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU00</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EPSAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAMAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IBS_CHAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCUAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PICU_PTAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCUAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_BKBCANFDAvlbly_RZCU_BKBCANFDAvlbly_RZCU_BKBCANFDAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SDMAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TDMAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b970400">
                          <SHORT-NAME>ICBVC_20ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_20ms_PDU03_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AMRPrtensonReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BPMMstrAvlbly</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_Group03_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PwrMdMstrAccryA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PwrMdMstrRunCrkA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysOpnlMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysPwrMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysPwrMdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysVol</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysVolMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysVolMdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysVolV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/UsgMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/UsgMdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehMdV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b940c00">
                          <SHORT-NAME>ICBVC_250ms_PDU52</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_250ms_PDU52_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_250ms_PDU52</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OtsdAirTemCrVal</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_OtsdAirTemCrValMsk</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OtsdAirTemCrValV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e327d900">
                          <SHORT-NAME>ICBVC_50ms_PDU11</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_PDU11_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU11</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsCanclSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsDistDecSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsDistIncSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsOnSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsRsmSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsSpdDecSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsSpdIncSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsSwDataIntgty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HMISafFltsts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group11_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PfTrTapUpDwnEnbSwSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PfTrTapUpDwnSecySwSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PfTrTapUpDwnSwSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SWSCnfmSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SWSSelDwnSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SWSSelLSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SWSSelRSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SWSSelUpSwA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/StrgWhlTipcSwDataIntgty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SwStaE2EErr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrPfShftPtrnSw1A</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrPfShftPtrnSw2A</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrPfShftPtrnSw3A</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrPfShftPtrnSw4A</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b968000">
                          <SHORT-NAME>ICBVC_50ms_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_PDU13_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutocParkngSwReq_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrSsdManuCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_CRC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_RC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved16</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group13_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMATESysSts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PwrMdCtrlResp_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtMdFICM_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TgtParkingChosed_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b98cc00">
                          <SHORT-NAME>ICBVC_50ms_PDU158</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_PDU158_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU158</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCDisAdjtVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCDisDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSpdDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSpdVcCmdSwReq_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSpdVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsCCASwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSwStsSetSwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_CRC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_RC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved13</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_Group158_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f44256900">
                          <SHORT-NAME>ICBVC_50ms_PDU55</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_50ms_PDU55_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU55</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDstrctnSts_DrvrDstrctnSts_DrvrDstrctnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrFtgLvl_DrvrFtgLvl_DrvrFtgLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMDrvrDstcnSts_ICMDrvrDstcnSts_ICMDrvrDstcnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMDrvrFtgLvl_ICMDrvrFtgLvl_ICMDrvrFtgLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMDrvrPrst_ICMDrvrPrst_ICMDrvrPrst</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICMEyeOnRoad_ICMEyeOnRoad_ICMEyeOnRoad</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b932400">
                          <SHORT-NAME>ICBVC_SecOCComKeyReq_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_SecOCComKeyReq_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOCComKeyReq_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ComKeyEnbReq_ComKeyEnbReq_ComKeyEnbReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TripCntResetReq_TripCntResetReq_TripCntResetReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a03148f4f31ca5800">
                          <SHORT-NAME>ICBVC_SecOC_SyncMsg1</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_SecOC_SyncMsg_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOC_SyncMsg</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ResetCnt_ResetCnt_ResetCnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TripCnt_TripCnt_TripCnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b932f00">
                          <SHORT-NAME>ICBVC_Sporadic_PDU138</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_Sporadic_PDU138_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_Sporadic_PDU138</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngReqICB_AIParkngReqICB_AIParkngReqICB</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b965f00">
                          <SHORT-NAME>ICB_100ms_PDU146</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_100ms_PDU146_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU146</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESCLPwrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHSWPwrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b902200">
                          <SHORT-NAME>ICB_100ms_PDU147</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_100ms_PDU147_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU147</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FDRPwrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLiDARPwrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b984500">
                          <SHORT-NAME>ICB_100ms_PDU159</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_100ms_PDU159_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU159</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCConfmSwReq_ACCConfmSwReq_ACCConfmSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCCurveSpdSwReq_ACCCurveSpdSwReq_ACCCurveSpdSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSpdLimtSwReq_ACCSpdLimtSwReq_ACCSpdLimtSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCStsSwReq_ACCStsSwReq_ACCStsSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCTJAMdSwReq_ACCTJAMdSwReq_ACCTJAMdSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ADAudioSWReq_ADAudioSWReq_ADAudioSWReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngSSPLotSw_AIParkngSSPLotSw_AIParkngSSPLotSw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IACCOvTSuppresSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ILCSwReq_ILCSwReq_ILCSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NonDirectDMSSwReq_NonDirectDMSSwReq_NonDirectDMSSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtOfstSetNumReq_SpdLmtOfstSetNumReq_SpdLmtOfstSetNumReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtOfstSetPercReq_SpdLmtOfstSetPercReq_SpdLmtOfstSetPercReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtOfstSetReq_SpdLmtOfstSetReq_SpdLmtOfstSetReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TLRMdSwReq_TLRMdSwReq_TLRMdSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TSRSwReq_TSRSwReq_TSRSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92b600">
                          <SHORT-NAME>ICB_100ms_PDU221</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_100ms_PDU221_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU221</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_AVPMapRutMgIDtReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDPowerFailSwReq_IPDPowerFailSwReq_IPDPowerFailSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RACtlReq_RACtlReq_RACtlReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92ab00">
                          <SHORT-NAME>ICB_100ms_PDU82</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_100ms_PDU82_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU82</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FCTSysSelReq_FCTSysSelReq_FCTSysSelReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b958e00">
                          <SHORT-NAME>ICB_500ms_PDU229</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_500ms_PDU229_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_500ms_PDU229</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NavCtryCode_ISO_NavCtryCode_ISO_NavCtryCode_ISO</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b92c100">
                          <SHORT-NAME>ICB_Sporadic_PDU67</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_Sporadic_PDU67_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_Sporadic_PDU67</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IdentityChlg_IdentityChlg_IdentityChlg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b902d00">
                          <SHORT-NAME>ICB_ZONE_100ms_PDU00</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_ZONE_100ms_PDU00_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_ZONE_100ms_PDU00</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ElecPwrDistbnScene</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b98e300">
                          <SHORT-NAME>IMM_50ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_PDU02_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DMSSts_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrAbnormBehvor_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrAbnormConf_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDstcnConf_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDstcnStsINST_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDstcnSts_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrFtgConf_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrFtgLvlINST_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrFtgLvl_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrGazeRgn_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrPrst_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EyeGazepitch_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EyeGazeyaw_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EyeOnRoad_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EyeOpenDegree_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EyeOpenStatus_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ILBRReq_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved143</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved151</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved159</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_Group02_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LeftEyeOccludeStatus_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MouthOccludeStatus_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/OMSSts_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RightEyeOccludeStatus_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpfngDet_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/YawnStatus_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b98ef00">
                          <SHORT-NAME>IMM_50ms_PDU04</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_50ms_PDU04_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU04</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DMSCameraFps_IMM_DMSCameraFps_IMM_DMSCameraFps_IMM</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b914000">
                          <SHORT-NAME>IPD_100ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU03_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjExistPrblty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjId</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjLatRltvDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjLongtRltvDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjLongtRltvSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjRisk</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjSyncCtr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCDetObjTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b936600">
                          <SHORT-NAME>IPD_100ms_PDU124</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU124_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU124</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_NrwroadFwdBtnDsp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_NrwroadFwdCndNotSt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDsp_NrwroadFwdDsp_NrwroadFwdDsp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDst360Req_NrwroadFwdDst360Req_NrwroadFwdDst360Req</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDstL_NrwroadFwdDstL_NrwroadFwdDstL</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDstR_NrwroadFwdDstR_NrwroadFwdDstR</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdReDst_NrwroadFwdReDst_NrwroadFwdReDst</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadFwdSwSts_NrwroadFwdSwSts_NrwroadFwdSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b937100">
                          <SHORT-NAME>IPD_100ms_PDU127</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU127_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU127</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RADSSwSts_RADSSwSts_RADSSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpedRegulaModSwSts_SpedRegulaModSwSts_SpedRegulaModSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b937c00">
                          <SHORT-NAME>IPD_100ms_PDU128</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU128_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU128</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_PDSysKeyPsAvlbl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b938700">
                          <SHORT-NAME>IPD_100ms_PDU130</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU130_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU130</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RASysSts_RASysSts_RASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b934500">
                          <SHORT-NAME>IPD_100ms_PDU16</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU16_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU16</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDAurixTemp_IPDAurixTemp_IPDAurixTemp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDPCBTemp1_IPDPCBTemp1_IPDPCBTemp1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDPCBTemp2_IPDPCBTemp2_IPDPCBTemp2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDPMICTemp_IPDPMICTemp_IPDPMICTemp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDSOCTemp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPDThermalWrnngLvl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b992700">
                          <SHORT-NAME>IPD_100ms_PDU35</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU35_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU35</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ADS_ISAMsgReq_ADS_ISAMsgReq_ADS_ISAMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ADS_ISASysFltSts_ADS_ISASysFltSts_ADS_ISASysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ADS_ISASysSts_ADS_ISASysSts_ADS_ISASysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_AIParkngSSPLotSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EORWarningEvtSts_EORWarningEvtSts_EORWarningEvtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HORWarningEvtSts_HORWarningEvtSts_HORWarningEvtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngSpdSwResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysADASFltSts_PilotSysADASFltSts_PilotSysADASFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrF1FltSts_PilotSysAVCamrF1FltSts_PilotSysAVCamrF1FltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrF3FltSts_PilotSysAVCamrF3FltSts_PilotSysAVCamrF3FltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrFLSFltSts_PilotSysAVCamrFLSFltSts_PilotSysAVCamrFLSFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrFRSFltSts_PilotSysAVCamrFRSFltSts_PilotSysAVCamrFRSFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrRFltSts_PilotSysAVCamrRFltSts_PilotSysAVCamrRFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrRLSFltSts_PilotSysAVCamrRLSFltSts_PilotSysAVCamrRLSFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysAVCamrRRSFltSts_PilotSysAVCamrRRSFltSts_PilotSysAVCamrRRSFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysFDRFltSts_PilotSysFDRFltSts_PilotSysFDRFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysFLIDARFltSts_PilotSysFLIDARFltSts_PilotSysFLIDARFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysHDAVMCamrFFltSts_PilotSysHDAVMCamrFFltSts_PilotSysHDAVMCamrFFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysHDAVMCamrLHFltSts_PilotSysHDAVMCamrLHFltSts_PilotSysHDAVMCamrLHFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysHDAVMCamrRFltSts_PilotSysHDAVMCamrRFltSts_PilotSysHDAVMCamrRFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysHDAVMCamrRHFltSts_PilotSysHDAVMCamrRHFltSts_PilotSysHDAVMCamrRHFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysLFSDAFltSts_PilotSysLFSDAFltSts_PilotSysLFSDAFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysLHRDAFltSts_PilotSysLHRDAFltSts_PilotSysLHRDAFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysRFSDAFltSts_PilotSysRFSDAFltSts_PilotSysRFSDAFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysRHRDAFltSts_PilotSysRHRDAFltSts_PilotSysRHRDAFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotSysUSSFltSts_PilotSysUSSFltSts_PilotSysUSSFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PosALCFailed_PosALCFailed_PosALCFailed</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFAudWrnng_IPD_SLIFAudWrnng_IPD_SLIFAudWrnng_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFSts_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFSysFltSts_SLIFSysFltSts_SLIFSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFUpdtIndResp_IPD_SLIFUpdtIndResp_IPD_SLIFUpdtIndResp_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFUpdtInd_IPD_SLIFUpdtInd_IPD_SLIFUpdtInd_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SLIFWrnngMdResp_SLIFWrnngMdResp_SLIFWrnngMdResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdAstSysTrgtSpd_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TSRSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TSRSwReqResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TSRTrgtBanSign</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TSRTrgtWarnSign</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrgtSpdSrcSts_IPD_TrgtSpdSrcSts_IPD_TrgtSpdSrcSts_IPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b985b00">
                          <SHORT-NAME>IPD_100ms_PDU50</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU50_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU50</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtCamrHeatCtrl_FrtCamrHeatCtrl_FrtCamrHeatCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b935000">
                          <SHORT-NAME>IPD_100ms_PDU58</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU58_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU58</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSpdLimtSw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCStsSw</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ADAudioSWSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/CCSpdlVcCmdSwReqDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IACCOvTSuppresCmd_IACCOvTSuppresCmd_IACCOvTSuppresCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IACCPreMsgReq_IACCPreMsgReq_IACCPreMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IACCPreSpdLimtCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPDAVCamrHeatReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NonDirectDMSSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NonDirectDMSSysSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngEndDis_ParkngEndDis_ParkngEndDis</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RAAlrWorDis_RAAlrWorDis_RAAlrWorDis</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLimitManualSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtMdMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtOfstSetNumResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SpdLmtOfstSetPercResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TJAICAMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TgtParkingFavorite_TgtParkingFavorite_TgtParkingFavorite</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b935b00">
                          <SHORT-NAME>IPD_100ms_PDU61</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_100ms_PDU61_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU61</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DetourMsgReq_DetourMsgReq_DetourMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSDspCmd_ESSDspCmd_ESSDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSUSSSts_FLSUSSSts_FLSUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLUSSSts_FLUSSSts_FLUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FMLUSSSts_FMLUSSSts_FMLUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FMRUSSSts_FMRUSSSts_FMRUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRSUSSSts_FRSUSSSts_FRSUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRUSSSts_FRUSSSts_FRUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HPPFnSts_HPPFnSts_HPPFnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HPPInBmtSts_HPPInBmtSts_HPPInBmtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HPPMapBuildSts_HPPMapBuildSts_HPPMapBuildSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HPPOnRoutSts_HPPOnRoutSts_HPPOnRoutSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/JAMsgReq_JAMsgReq_JAMsgReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSCurToEndPntDist_LADSCurToEndPntDist_LADSCurToEndPntDist</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LCRInHMI_LCRInHMI_LCRInHMI</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LCRSwDspCmd_LCRSwDspCmd_LCRSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOACitySysMsg_NOACitySysMsg_NOACitySysMsg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOADistDecMsg_NOADistDecMsg_NOADistDecMsg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAETCSetDspCmd_NOAETCSetDspCmd_NOAETCSetDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOALaneSetDspCmd_NOALaneSetDspCmd_NOALaneSetDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_NOAQukChgSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOAReportSetDspCmd_NOAReportSetDspCmd_NOAReportSetDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPCitySwDspCmd_NOPCitySwDspCmd_NOPCitySwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPSwDspCmd_NOPSwDspCmd_NOPSwDspCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPSysMsg_NOPSysMsg_NOPSysMsg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NarRoVslAssSwResp_NarRoVslAssSwResp_NarRoVslAssSwResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadBwdAssMesg_NrwroadBwdAssMesg_NrwroadBwdAssMesg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_NrwroadBwdAssSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PEBSts_PEBSts_PEBSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PEBSwResp_PEBSwResp_PEBSwResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PEBWarngReq_PEBWarngReq_PEBWarngReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngDirAvlSts_ParkngDirAvlSts_ParkngDirAvlSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngDirSwResp_ParkngDirSwResp_ParkngDirSwResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutBkCrsSts_ParkngOutBkCrsSts_ParkngOutBkCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutBkLCrsSts_ParkngOutBkLCrsSts_ParkngOutBkLCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutBkRCrsSts_ParkngOutBkRCrsSts_ParkngOutBkRCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutDircnSelResult_ParkngOutDircnSelResult_ParkngOutDircnSelResult</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutFLCrsSts_ParkngOutFLCrsSts_ParkngOutFLCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutFLParllSts_ParkngOutFLParllSts_ParkngOutFLParllSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutFRCrsSts_ParkngOutFRCrsSts_ParkngOutFRCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutFRParllSts_ParkngOutFRParllSts_ParkngOutFRParllSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngOutFrtCrsSts_ParkngOutFrtCrsSts_ParkngOutFrtCrsSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ParkngSlotFindSts_ParkngSlotFindSts_ParkngSlotFindSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLSUSSSts_RLSUSSSts_RLSUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLUSSSts_RLUSSSts_RLUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RMLUSSSts_RMLUSSSts_RMLUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RMRUSSSts_RMRUSSSts_RMRUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRSUSSSts_RRSUSSSts_RRSUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRUSSSts_RRUSSSts_RRUSSSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b933a00">
                          <SHORT-NAME>IPD_10ms_PDU59</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_10ms_PDU59_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_10ms_PDU59</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAParkInOffsetType_APAParkInOffsetType_APAParkInOffsetType</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APARemShifGear_APARemShifGear_APARemShifGear</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASW_APASW_APASW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b951400">
                          <SHORT-NAME>IPD_20ms_PDU43</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_PDU43_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group43_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b991b00">
                          <SHORT-NAME>IPD_20ms_PDU60</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_20ms_PDU60_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU60</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_Group60_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NOPSysSts_ZPD_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Parkngslottype_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PilotTkovMsgReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PrkgDstCtrlSwResp_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b93ea00">
                          <SHORT-NAME>IPD_50ms_PDU14</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_PDU14_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU14</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_CRC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_RC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved10</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved11</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group14_Reserved9</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSInfoDispReqToICM_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSInfoDispReq_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSProgressBar_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SDWLSFObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SDWLSRObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SDWRSFObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SDWRSRObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f444be400">
                          <SHORT-NAME>IPD_50ms_PDU49</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_50ms_PDU49_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/APAEnRunReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_Group49_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/KeepPwrRsnIPD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SysPwrMdCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b979e00">
                          <SHORT-NAME>IPD_BKBCANFD_EvtInfo1</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKBCANFD_EvtInfo_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_BKBCANFD_EvtInfo</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD1_EvtPotclSigIPD1_EvtPotclSigIPD1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD2_EvtPotclSigIPD2_EvtPotclSigIPD2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD3_EvtPotclSigIPD3_EvtPotclSigIPD3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD4_EvtPotclSigIPD4_EvtPotclSigIPD4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD5_EvtPotclSigIPD5_EvtPotclSigIPD5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD6_EvtPotclSigIPD6_EvtPotclSigIPD6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD7_EvtPotclSigIPD7_EvtPotclSigIPD7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EvtPotclSigIPD8_EvtPotclSigIPD8_EvtPotclSigIPD8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b90dd00">
                          <SHORT-NAME>IPD_Sporadic_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_Sporadic_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgCheckSum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgOVS</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgSGW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgSequenceCounter</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgTime</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgTimeDomain</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgType</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SyncMsgreserved</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b939200">
                          <SHORT-NAME>IPD_Sporadic_PDU13</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_Sporadic_PDU13_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU13</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDIdentityResp_IPDIdentityResp_IPDIdentityResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b939d00">
                          <SHORT-NAME>IPD_Sporadic_PDU35</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_Sporadic_PDU35_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU35</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AIParkngRespICB_AIParkngRespICB_AIParkngRespICB</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPDComKeyEnbResp_IPDComKeyEnbResp_IPDComKeyEnbResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b986600">
                          <SHORT-NAME>LHZCU_100ms_PDU14</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_PDU14_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU14</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TemSnsrHdwrFltPrst_TemSnsrHdwrFltPrst_TemSnsrHdwrFltPrst</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8feb00">
                          <SHORT-NAME>LHZCU_100ms_PDU15</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_PDU15_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU15</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtWindShldSfcTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtWindShldSurndHmdty</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtWindShldSurndTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtWiperSpd_FrtWiperSpd_FrtWiperSpd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b966a00">
                          <SHORT-NAME>LHZCU_100ms_PDU16</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_PDU16_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU16</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLDoorOpenSts_FLDoorOpenSts_FLDoorOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtPsngDoorOpenSts_LHZCU</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HmdtySnsrHdwrFltPrst</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8ff600">
                          <SHORT-NAME>LHZCU_100ms_PDU22</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_PDU22_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU22</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FrtWiperSwSts_FrtWiperSwSts_FrtWiperSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b956200">
                          <SHORT-NAME>LHZCU_100ms_PDU30</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_100ms_PDU30_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU30</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnIndLampSwStsMntry_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSeatHorzPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLSeatVertPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_CRC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_RC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved12</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved87</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_Group30_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b989300">
                          <SHORT-NAME>LHZCU_10ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DigKeyAuthReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DigKeyPEValidReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrReqParkBtn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/KeyAuthResp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group01_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group01_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group01_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group01_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUAPAUnderCtrlActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUDrvMd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUDrvrIntrvnActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUExtdShiftrFlr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUFltLvlWarn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUParkLckReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUParkLckReqEPMCU</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUParkLckReqV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUParkLckReqVEPMCU</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShiftrLvrPosn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShiftrLvrPosnLtchActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShiftrLvrRawPosn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShiftrOpngRmndr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShiftrPosnInvsn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SecuKeyVldSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b940000">
                          <SHORT-NAME>LHZCU_10ms_PDU32</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_10ms_PDU32_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU32</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnLghtOnReq_LHZCU</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrReqGearShftPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrReqGearShftPosInvs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/EleccTrRngReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LDayTimeRunningLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCUWKSTS_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_Group32_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MainBeamLghtSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RDayTimeRunningLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RrFogLightOnReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUActrMvmntSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUDrvnIntrvnPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUExtdShifterActrPos</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUParkActrSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShftLvrPosIncnstntFlag</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUShftLvrPosTrgt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUTapUpDwnSwSta</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SCUTapUpDwnSwStaInvsn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SideLghtOnReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SmrtKey4LoctnResp_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SmrtKeyLoctnFlrRsn_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SmrtKeyLoctnProc_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b90f300">
                          <SHORT-NAME>LHZCU_20ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_20ms_PDU03_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_20ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DippedBeamActStatus_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLDircnLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRDircnLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HzrdLghtSwReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_Group03_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LMainBeamLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PriySSBAV_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/PriySSBA_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDircnLghtCtrl_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RMainBeamLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRDircnLghtCtrl_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RevsLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SSBTrigd_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SecySSBAV_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SecySSBA_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b95a400">
                          <SHORT-NAME>LHZCU_400ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_400ms_PDU01_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLTirePrs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLTirePrsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLTireSts_FLTireSts_FLTireSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRTirePrs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRTirePrsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRTireSts_FRTireSts_FRTireSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLTirePrs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLTirePrsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLTireSts_RLTireSts_RLTireSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRTirePrs</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRTirePrsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRTireSts_RRTireSts_RRTireSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMSWntrMdA</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b963e00">
                          <SHORT-NAME>LHZCU_400ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_400ms_PDU03_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLTireTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLTireTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRTireTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRTireTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLTireTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLTireTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRTireTem</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRTireTemV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fca00">
                          <SHORT-NAME>LHZCU_50ms_PDU04</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU04_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU04</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnIndLghtMdSts_DircnIndLghtMdSts_DircnIndLghtMdSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnIndLghtSwSts_DircnIndLghtSwSts_DircnIndLghtSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLDoorHndlPESwtActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FRDoorHndlPESwtActv</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fd500">
                          <SHORT-NAME>LHZCU_50ms_PDU06</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU06_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU06</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BntOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DirnLghtSftyMonErr_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDetSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DrvrDoorOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group06_Reserved8</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLDoorOpenSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLSInitnFltPrst_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehLckSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b93c900">
                          <SHORT-NAME>LHZCU_50ms_PDU08</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU08_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU08</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SideLghtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b964900">
                          <SHORT-NAME>LHZCU_50ms_PDU24</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU24_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU24</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtFltSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BrkLghtSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnLghtFltsts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnLghtMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DircnLghtSwReq_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/HUDLkngAmbtLghtLvlByLux_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_CRC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_RC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved121</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved135</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved143</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved151</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved159</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved23</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved49</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved60</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved81</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved87</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_Group24_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RLSideLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RRSideLghtCtrl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehHzrdMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehIlluminateCtrlCmd_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/VehSideLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8fe000">
                          <SHORT-NAME>LHZCU_50ms_PDU34</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU34_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU34</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/AutoMainBeamLghtOn_AutoMainBeamLghtOn_AutoMainBeamLghtOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/MainBeamLghtOn_MainBeamLghtOn_MainBeamLghtOn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrdtnSmrtKyLckSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrdtnSmrtKyUnlckSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b980200">
                          <SHORT-NAME>LHZCU_50ms_PDU58</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_50ms_PDU58_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU58</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrdtnKeyBtnSts_TrdtnKeyBtnSts_TrdtnKeyBtnSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrdtnSmrtKyFindCarSwSts_TrdtnSmrtKyFindCarSwSts_TrdtnSmrtKyFindCarSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TrdtnSmrtKyLdspcSwSts_TrdtnSmrtKyLdspcSwSts_TrdtnSmrtKyLdspcSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b900100">
                          <SHORT-NAME>LHZCU_ICBVC_50ms_PDU14</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_ICBVC_50ms_PDU14_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FLDircnLghtSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b909b00">
                          <SHORT-NAME>NmPDU_BKPCANFD_FDR</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_FDR_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b975100">
                          <SHORT-NAME>NmPDU_BKPCANFD_IMM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_IMM_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b905900">
                          <SHORT-NAME>NmPDU_BKPCANFD_IPD</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_IPD_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b943800">
                          <SHORT-NAME>NmPDU_BKPCANFD_LFSDA</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_LFSDA_IPD_BKPCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b944300">
                          <SHORT-NAME>NmPDU_BKPCANFD_LHRDA</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/NmPDU_BKPCANFD_LHRDA_IPD_BKPCANFD</I-PDU-PORT-REF>
